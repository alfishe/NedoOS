-Z(CODE)CODE,RCODE,CDATA0,CONST,CSTR,CCSTR,DATA0,IDATA0,UDATA0,ECSTR,CSTACK+200=0100-7FFF
