-Z(CODE)KRST=F000-FFFF
