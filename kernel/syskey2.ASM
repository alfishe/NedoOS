numlangs=3 ;включая graph

keyqueuemax=5

kZ=0 ;яверты
kJ=0 ;йцукен
multikbd=0
kR=1 ;шверты
NkJ=kZ+kR 
ukr=1

KEYSCAN
;для autosave и моргания ovr
       ;CALL KEYMATRIX ;-> AFBC
       ;CALL KEYREP ;AFBC -> A
       ;CALL KEYALTGR ;A -> BC
       ;CALL KEYSWITCH ;BC -> BC
       ;CALL KEYLANG ;BC -> BC
       ;CALL KEYQUEUEPUT ;BC -> очередь
;дальше попасть невозможно (см. KEYGET, KEYPUT)

KEYMATRIX
        LD HL,tkeymatrixstate
        LD BC,#7FFE ;Space=0, cs=35
        IN A,(C)
        RRA 
        RRA ;ss
        LD A,C
        IN A,(#FE)
        RLA 
        AND 3
        LD (keymshifts),A ;A0=ss,A1=cs
        LD E,0 ;сканкод
KEYM0   IN A,(C)
        LD (keym0BC),BC
        LD (keym0HL),HL
        LD C,(HL),(HL),A
        XOR C ;C=старое состояние
        LD D,A ;D=изменения
        LD B,5
KEYM1   RR D
        jr NC,KEYMnPUT
        LD (keym1BC),BC
        LD (keym1DE),DE
keymshifts=$+1
        LD D,0
       LD A,E
       CP 35 ;cs
       jr NZ,$+3
       LD C,A ;отж cs выдает наж cs без шифтов (для ALTGR)
;C0=наж(1)/отж(0)
;E=сканкод, D=shiftstate
;D=%00: ext
;D=%01: cs
;D=%10: ss
;D=%11: без шифтов
        LD HL,tkeydecode
        LD A,-32
        DEC D
        jr Z,KEYDECODEPASS ;cs
        XOR A
        DEC D
        jr NZ,KEYDECODEnoss
        LD HL,tkeydecodess
        JR KEYDECODEPASS
KEYDECODEnoss
;A=0
        DEC D
        jr Z,KEYDECODEPASS
        LD D,A ;=0
        ;LD A,extbase ;128
         LD HL,tkeydecodeext ;TODO fix: ¤Єш ъюф√ <32 сєфєЄ яхЁхёўшЄрэ√ ъръ  ъюс√ cs+ъюф√!
KEYDECODEPASS
        ADD HL,DE
        ADD A,(HL)
         cp (Enter-32)&0xff
         ld d,csEnter
         jr z,KEYDECODE_fixCPM
         cp (' '-32)&0xff
         ld d,csSpace
         jr z,KEYDECODE_fixCPM
         ;cp ('0'-32)&0xff
         ;ld d,cs0
         ;jr z,KEYDECODE_fixCPM ;see in ALTGR
         ;sub '0'-32
         ;cp 10
         ;jr nc,$+4
         ;add a,cs1-1-('0'-32)
         ;add a,'0'-32
         ld d,a
KEYDECODE_fixCPM
         ld a,d
;не передавать нажатие cs+cs или ss+ss (а cs без шифтов надо)
;(т.к. убьёт автоповтор кнопок с ними)
;ext+cs убивает автоповтор ext+стрелок
       ;CP sscs
       ;jr Z,KEYMPUTSKIP
;или задержать на фрейм нажатие цифробукв относительно шифтов
       CP ss ;важно для автоповтора ssSpace
       jr Z,KEYMPUTSKIP
       CP cs
      ;jr Z,KEYMPUTSKIP
       LD B,E
        CALL NZ,KEYREP ;A=code
                       ;C0=press(1)/release(0)
                       ;ZF=0: no blowing, =1: blowing
                       ;B=scancode without shifts
KEYMPUTSKIP
keym1DE=$+1
        LD DE,0
keym1BC=$+1
        LD BC,0
KEYMnPUT
        INC E
        RR C
        DJNZ KEYM1
keym0HL=$+1
        LD HL,0
        INC HL
keym0BC=$+1
        LD BC,0
        RRC B ;след. полуряд
        jr C,KEYM0
        XOR A
       ;CALL KEYREP ;ZF=1: blowing
       ;POP HL ;выход в CALL:CALL:CALL
       ;RET ;выход из конвейера

;C0=press(1)/release(0)
;A=code
;ZF=0: no blowing, =1: blowing
;B=scancode without shifts
KEYREP
        jr NZ,KEYREPNOBLOW
keyrepcounter=$+1
        LD A,0
        OR A
  RET Z;JZ KEYREPGET
        DEC A
        jr Z,KEYREPSEND
KEYREPSETCNT
        LD (keyrepcounter),A
   RET ;JR KEYREPGET
KEYREPNOBLOW
        IF 1==0
        push af
        push bc
        push de
        push hl
        ld a,b
        add a,'A'
        ld c,a
        ld b,0
        call KEYQUEUEPUT
        ld a,(keyrepscancode)
        add a,'A'
        ld c,a
        ld b,0
        call KEYQUEUEPUT
        pop hl
        pop de
        pop bc
        pop af
        ENDIF
        RR C ;NC=release
        jr C,KEYREPPRESS
;CP/M: if "ext" is released, then make "ext" keypress
         ld a,(keyrepkey)
         cp csss
         jr z,KEYREPSEND
;if the repeated key (without shifts) is released
;then stop key repeat
;or else ignore
       LD A,B ;scancode without shifts
keyrepscancode=$+1
       SUB -1
 RET NZ;JNZ KEYREPGET
      ;XOR A
       JR KEYREPSETCNT
KEYREPPRESS
        LD (keyrepkey),A

;CP/M: no "ext" keypress
        cp csss
        ret z

       CP csnoshifts
       jr Z,KEYREPSEND ;no autorep for csnoshifts
       SUB '1'-32
       CP 2
       jr C,KEYREPSEND ;no autorep for cs1..2
       LD A,B ;scancode without shifts
       LD (keyrepscancode),A
        LD A,14;10
        LD (keyrepcounter),A
KEYREPSEND
keyrepkey=$+1
        LD A,0
       ;CALL KEYALTGR ;A=code
;KEYREPGET
  ;RET ;CALL KEYGET
       ;JR KEYREP

;A = code (cs+0 is encoded as '0'-32)
;csnoshifts means CS release
;idle: cs1..2 start, csnoshifts skip, others pass by
;working: cs0..9 add, others end (1,2 add cs0)
;long cs1..2 = symbols because of autorep
KEYALTGR
altgrN=$+1
        LD BC,#100 ;C=code, B=1 (codes)
        SUB '0'-32;cs0 ;<32!
       LD D,A ;0..9 in good case
       INC C
       DEC C
       jr Z,KEYALTGRIDLE
        CP 10
       LD A,C
        jr NC,KEYALTGRPASS ;skip event (csnoshifts)
        ADD A,A
        ADD A,A
        ADD A,C
        ADD A,A ;D*10
        ADD A,D
KEYALTGRN
        LD (altgrN),A
   RET ;JR KEYALTGRGET ;add
KEYALTGRIDLE
;A=1..2 in good case
        DEC A
        CP 2 ;CY=1: cs1/cs2
        INC A
        jr C,KEYALTGRN ;start
        JR KEYALTGRPUTCTRL
KEYALTGRPASS
       CP 3
       jr NC,KEYALTGRPUT
KEYALTGRPUTCTRL
        ADD A,'0'-32;cs0
        INC B ;control keys
KEYALTGRPUT
         sub '0'-32
         cp 10
         jr nc,KEYALTGRPUT_norecodecsN
         or a ;a=0..9
         jr nz,$+4
         ld a,0xff&(cs0-(cs1-1))
         add a,cs1-1-('0'-32)
KEYALTGRPUT_norecodecsN
         add a,'0'-32
        LD C,A
       XOR A
       LD (altgrN),A ;idle
       ;CALL KEYSWITCH ;BC=code (B=1 means KEYLANG passby)
;KEYALTGRGET
  ;RET ;CALL KEYGET ;A=code
       ;JR KEYALTGR

;BC=code (B=2 => might be control code) (B=1 means KEYLANG passby)
KEYSWITCH
       DEC B
       jr Z,KEYSWPASS ;B=0
        LD A,C
        ;push af
        ;push bc
        ;ld bc,'a'
        ;ld c,a
        ;call KEYQUEUEPUT
        ;pop bc
        ;pop af
keyswstate=$+1
        LD HL,#100 ;H=язык=1..numlangs (H=numlangs при graph)
                   ;L0=CapsLock
        CP cs2
        jr Z,KEYSWCAPSLOCK
        CP cs1
        jr Z,KEYSWLANG
        CP ext1
        jr NZ,KEYSWPASS
KEYSWGRAPH
        LD A,H
        LD H,numlangs
        CP H ;graph уже включен?
        jr NZ,KEYSWOK ;нет - включаем, иначе DEC H
KEYSWLANG
        DEC H
        jr NZ,$+4
        LD H,numlangs-1
        DEC L
KEYSWCAPSLOCK
        INC L
KEYSWOK
        LD (keyswstate),HL
;пускаем кнопку для возможности перепечатки курсора
KEYSWPASS
       ;CALL KEYLANG ;BC=code
  ;RET ;CALL KEYGET
       ;JR KEYSWITCH

KEYLANG
        INC B
        DEC B
        jr Z,KEYLANGPASS ;B=0: symbol from ALTGR
;B=1
        ;CALL KEYQUEUEPUT ;BC=code
        ld (keyqueueput_codenolang),bc
        LD A,C
        LD (keylangcode),A
        SUB 32
        CP 95
        jr NC,KEYLANGPASS ;B=1
;дублируем упр. код
;будет упр. код (неязыковой), потом символ (языковой)
;первое нужно для JUMPKEY, второе для ввода текста
        ;CALL KEYQUEUEPUT ;BC=code
rustrdisp=$+1
       LD DE,0 ;D=0
       INC E
       DEC E
       jr NZ,KEYLANG_SHV2
keylangcode=$+1
        LD BC,0 ;B=0, C=code
        LD DE,(keyswstate)
;BC=code
        DEC D
        jr Z,KEYL_ENG ;B=0
        DEC D
        jr NZ,KEYL_GRAPH ;B=0
KEYL_RUSTR
;B=0
       IF multikbd
kmode=$+1
        LD A,1
        CP kR
        jr Z,KEYL_SHVERTY
        CALL RERUS
        JR KEYLANGPUT ;B=0
KEYL_SHVERTY
       ENDIF 
        LD A,C
        CP 64
        jr C,KEYLANGPUT ;B=0
        LD HL,tkeyl_rustr
        ADD HL,BC
        LD C,(HL)
        LD A,C
        CP 64
        jr NC,KEYLANGPUT ;B=0
       ;LD (rustrdisp),BC ;B=0
      ;LD A,C
       LD (rustrdisp),A
  RET ;JR KEYLANGGET
KEYLANG_SHV2
        LD (rustrNEW),BC
       LD A,C;(rustrNEW)
      ;LD (rustrNEW),A
;rustrdisp=$+1
       ;LD DE,0 ;D=0
        LD HL,tkeyl_rustrc
        ADD HL,DE
        LD C,(HL) ;len
       LD B,D ;=0
        INC HL
        LD E,C
        CPIR 
        LD C,E ;B=0
        ADD HL,BC
        jr Z,KEYLANGCOMBO ;введена комбинация
;нет такой комбинации - берем символ номер len
       LD A,(HL)
       CALL case
       LD C,A
        CALL KEYQUEUEPUT ;B=0
rustrNEW=$+1
       LD BC,0 ;B=0
       XOR A
       LD (rustrdisp),A
        JR KEYLANG ;дублирование и перекодирование 2-го кода
KEYL_GRAPH
;B=0
        LD HL,tkeyl_graph+1
        ADD HL,BC
KEYLANGCOMBO
        DEC HL
        LD C,(HL)
KEYL_ENG ;B=0
KEYLANGPUT ;B=0
       LD A,C
       CALL case
       LD C,A
KEYLANGPASS
       XOR A
       LD (rustrdisp),A
       ;CALL KEYQUEUEPUT ;BC=code (B=0/1)
;KEYLANGGET
  ;RET ;CALL KEYGET ;BC=code
       ;JR KEYLANG

;KEYQUEUEPUTLOOP
  ;RET ;CALL KEYGET ;BC=code
KEYQUEUEPUT
keyqueueN=$+1
        LD A,0 ;уменьшается ПОСЛЕ чтения из очереди
        CP keyqueuemax
 RET Z ;jr Z,KEYQUEUEPUTLOOP ;skip
        INC A
        LD (keyqueueN),A
;ALTGR codes: b=0, c=0..255
;letters: b=0, c>=32
;control codes: b=1, c=0..31, #bx, #cx, #dx, #fx
        
;result:
;b=1, c=#8x, #9x for ALTGR codes 0..31
keyqueuehead=$+1
        LD HL,tkeyqueue
        LD (HL),C
        INC HL
        LD (HL),B
        CALL KEYQUEUEINCHL
keyqueueput_codenolang=$+1
        ld bc,0
        LD (HL),C
        INC HL
        LD (HL),B
        CALL KEYQUEUEINCHL
        LD (keyqueuehead),HL
   RET ;JR KEYQUEUEPUTLOOP

tkeydecodeext
        DB extSpace,csss,extM,extN,extB
        DB extEnter,extL,extK,extJ,extH
        DB extP,extO,extI,extU,extY
        DB ext0,ext9,ext8,ext7,ext6
        DB ext1,ext2,ext3,ext4,ext5
        DB extQ,extW,extE,extR,extT
        DB extA,extS,extD,extF,extG
        DB csss,extZ,extX,extC,extV

tkeydecode
        DB " ",ssnoshifts,"mnb"
        DB Enter,"lkjh"
        DB "poiuy"
        DB "09876"
        DB "12345"
        DB "qwert"
        DB "asdfg"
        DB csnoshifts,"zxcv"
tkeydecodess
        DB ssSpace,ss,".,*"
        DB ssEnter,"=+-^"
        DB 34,";",ssI,"]["
        DB "_)('&"
        DB "!@#$%"
        DB ssQ,ssW,ssE,"<>"
        DB "~|",#5c,"{}"
        DB csss,":`?/" ;csss is taken from tkeydecodeext in fact
tkeymatrixstate
        DS 8,#FF ;изначально ничего не нажато

tkeyl_graph=$-32
        DB 32,14,34,16,17,18,19,20,"()*+,-./"
        DB 12,1,2,3,4,5,6,7,8,11,":;єўЄ?"
        DB 15,"╠╧╝╣╗╞╪╡▄▀■¤№╛▌▐╔╒╬╤█╘╦╩╕╚[",#5c,"]^_"
        DB "`├╨┘┤┐╟╫╢─░▒▓√╜║═┌╓┼╥│╙┬┴╖└{|}~"
tkeyl_rustr=$-64
        DB "@АБ",rustrCdisp
        DB "ДЕФГ",rustrHdisp,"И",rustrJdisp
        DB "КЛМНОП",rustrQdisp
        DB "РСТУЖВЬЫЗ[",#5c,"]^_"
        DB "`аб",rustrcdisp
        DB "дефг",rustrhdisp,"и",rustrjdisp
        DB "клмноп",rustrqdisp
        DB "рстужвьыз{|}~"

tkeyl_rustrc=$-1 ;чтобы не было нулевых смещений
rustrhdisp=$-tkeyl_rustrc
        DB 1,"h","э","х"
rustrHdisp=$-tkeyl_rustrc
        DB 1,"H","Э","Х"
rustrqdisp=$-tkeyl_rustrc
        DB 1,"q","щ","ш"
rustrQdisp=$-tkeyl_rustrc
        DB 1,"Q","Щ","Ш"
rustrcdisp=$-tkeyl_rustrc
       IF ukr
        DB 2,"gc",#F3,"ц","ч"
       ELSE 
        DB 1,"c","ц","ч"
       ENDIF 
rustrCdisp=$-tkeyl_rustrc
       IF ukr
        DB 2,"GC",#F2,"Ц","Ч"
       ELSE 
        DB 1,"C","Ц","Ч"
       ENDIF 
rustrjdisp=$-tkeyl_rustrc
       IF ukr
        DB 7,"eyiaouj",#F5,#F7,#F9,"яёюъ","й"
       ELSE 
        DB 4,"aouj","яёюъ","й"
       ENDIF 
rustrJdisp=$-tkeyl_rustrc
        DISPLAY $-tkeyl_rustrc,"<64"
       IF ukr
        DB 7,"EYIAOUJ",#F4,#F6,#F8,"ЯЁЮЪ","Й"
       ELSE 
        DB 4,"AOUJ","ЯЁЮЪ","Й"
       ENDIF 

       IF kZ
rt
        DB "ЮАБЦДЕФГХИЙКЛМНОПЯРСТУЖВЬЫЗШЭЩЧъ"
       ENDIF 
       IF kJ
rtjcuk
        DB "@ФИСВУАПРШОЛДЬТЩЗЙКЫЕГМЦЧНЯ[",#5c,"]^_"
       ENDIF 
RERUS
;in:C=код (32..126), A=kmode
;out:C=код
;не портит B
        LD D,C ;код
       IF kZ
        LD HL,rt
       ENDIF 
       IF kJ
        IF multikbd
        CP NkJ
        jr NZ,rERUSnJCUK
        ENDIF 
        LD HL,rtjcuk
        LD A,D ;код
        LD C,'б'
        CP '!'
        RET Z
        LD C,'ж'
        CP '@'
        RET Z
        LD C,'х'
        SUB '#'
        RET Z
        LD C,'э'
        DEC A ;'$'
        RET Z
        INC C ;'ю'
        DEC A ;'%'
        RET Z
rERUSnJCUK ;
       ENDIF 
        LD A,D ;код (32..126)
        LD C,'ё'
        CP '&'
        RET Z
        LD C,D
        BIT 6,D ;код
        RET Z ;код <64 (не буква) - возвращаем его
;A=код (64..126)
        AND 31
        ADD A,L
        LD L,A
        jr NC,$+3
        INC H
        LD A,(HL) ;заглавная русская
        BIT 7,A
        RET Z ;в таблице не буква - возвращаем старый код
        LD C,A ;заглавная русская
        BIT 5,D ;код
        RET Z ;в C была заглавная, выдаем заглавную
        CALL RECAP
        LD C,A ;строчная русская
        RET 

CHECKCAPSLOCK
        PUSH HL
        LD HL,keyswstate
        BIT 0,(HL)
        POP HL
        RET 
case
        CALL CHECKCAPSLOCK
        RET Z
RECAP
        CP 0xf2;je'Є'
        RET NC
        XOR 1
        CP 0xf0;jo'Ё'
        RET NC
        XOR 1
        CP 0xe0;'р'
        jr NC,BECAPRL
        CP 0xb0;'-'
        RET NC
        CP 0xa0;'а'
        jr NC,BECAPOK
        CP 0x90;'Р'
        jr NC,BECAPRL
        CP 0x80;'А'
        jr NC,BECAPOK
        CP '@'
        RET Z
        CP '_'
        RET Z
        CP 'A'
        RET C
        CP '{'
        RET NC
        CP '['
        jr C,$+5
        CP 'a'
        RET C
BECAPOK XOR 80
BECAPRL XOR #70
        RET 

KEYQUEUEINCHL
        INC HL
        LD A,L
        CP tkeyqueueend&0xff
        RET NZ
        LD HL,tkeyqueue
        RET 
        
tkeyqueue
        DS 4*keyqueuemax
tkeyqueueend

PEEKKEY
        LD A,(keyqueueN)
        OR A
        ld h,a
        RET Z ;a=NOKEY, h=0
        LD HL,(keyqueuetail)
        LD a,(HL)
        INC HL
        LD h,(HL)
        ret
        
GETKEY
;H=1 для упр. кодов, H=0 для символов
;out: ha=key (NOKEY=none), keeps de,l
        LD A,(keyqueueN)
        OR A
        ld h,a
        RET Z ;a=NOKEY, h=0
        PUSH HL
keyqueuetail=$+1
        LD HL,tkeyqueue
;2 bytes with language
;2 bytes without language
        LD C,(HL)
        INC HL
        LD B,(HL)
         ld a,b
         or a
         jr z,getkey_noskipcapslock
         ld a,c
         cp cs2
         jr z,getkey_skipcapslock
         cp cs1
         jr nz,getkey_noskipcapslock
getkey_skipcapslock
         ld c,NOKEY
getkey_noskipcapslock
        CALL KEYQUEUEINCHL
        ;LD C,(HL)
        INC HL
        ;LD B,(HL)
GETKEY_q        
        CALL KEYQUEUEINCHL
        LD (keyqueuetail),HL
        LD HL,keyqueueN
        DEC (HL) ;обязательно АТОМАРНОЙ операцией
             ;(иначе можем прозевать увеличение keyqueueN)
                 ;и ПОСЛЕ чтения
             ;(иначе во время чтения события его могут затереть)
        LD A,C
        ;DEC H ;NZ
        POP HL
        ld h,b
        RET 

GETKEYNOLANG
        LD A,(keyqueueN)
        OR A
        ld h,a
        RET Z ;a=NOKEY, h=0
        PUSH HL
        LD HL,(keyqueuetail)
        ;LD C,(HL)
        INC HL
        ;LD B,(HL)
        CALL KEYQUEUEINCHL
        LD C,(HL)
        INC HL
        LD B,(HL)
        jr GETKEY_q
