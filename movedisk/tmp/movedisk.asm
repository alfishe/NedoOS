copybody
	LD HL,[copybody.from]
	LD [copybody.nextrdsector],HL
	LD HL,[copybody.to]
	LD [copybody.nextwrsector],HL
copybody.D.
	LD A,[copybody.count]
	LD E,0x00
	LD L,A
	LD A,E
	SUB L
	JP NC,copybody.E.
	LD A,[copybody.count]
	LD E,BUFSECTORS
	SUB E
	JP C,copybody.F.
	LD A,BUFSECTORS
	LD [copybody.wrsectors],A
	JP copybody.G.
copybody.F.
	LD A,[copybody.count]
	LD [copybody.wrsectors],A
copybody.G.
	LD HL,buf
	LD [readsectors.A.],HL
	LD HL,[copybody.nextrdsector]
	LD [readsectors.B.],HL
	LD A,[copybody.wrsectors]
	LD [readsectors.C.],A
	CALL readsectors
	LD [copybody.nextrdsector],HL
	LD HL,buf
	LD [writesectors.A.],HL
	LD HL,[copybody.nextwrsector]
	LD [writesectors.B.],HL
	LD A,[copybody.wrsectors]
	LD [writesectors.C.],A
	CALL writesectors
	LD [copybody.nextwrsector],HL
	LD A,[copybody.count]
	LD L,A
	LD A,[copybody.wrsectors]
	LD E,A
	LD A,L
	SUB E
	LD [copybody.count],A
	JP copybody.D.
copybody.E.
	LD HL,[copybody.nextwrsector]
	RET
movedisk
	LD HL,psystrk
	LD [readsectors.A.],HL
	LD HL,0x0000
	LD [readsectors.B.],HL
	LD A,0x09
	LD [readsectors.C.],A
	CALL readsectors
	LD A,0x00
	LD [movedisk.nfiles],A
	LD HL,psystrk
	LD DE,0x8e5
	ADD HL,DE
	LD A,[HL]
	INC HL
	LD H,[HL]
	LD L,A
	LD [movedisk.nfreesectors],HL
	LD HL,0x0100
	LD [movedisk.freeplace],HL
	LD HL,psystrk
	LD [movedisk.freefiledesc],HL
	LD HL,psystrk
	LD [movedisk.curfiledesc],HL
movedisk.loop
	LD HL,[movedisk.curfiledesc]
	LD A,[HL]
	SUB 0x00
	JP NZ,movedisk.A.
	JP movedisk.quit
movedisk.A.
	LD HL,[movedisk.curfiledesc]
	LD A,0x0d
	LD E,A
	LD D,0
	ADD HL,DE
	LD A,[HL]
	LD [movedisk.count],A
	LD HL,[movedisk.curfiledesc]
	LD A,[HL]
	SUB 0x01
	JP NZ,movedisk.C.
	LD HL,[movedisk.nfreesectors]
	LD A,[movedisk.count]
	LD E,A
	LD D,0
	ADD HL,DE
	LD [movedisk.nfreesectors],HL
	JP movedisk.next
movedisk.C.
	LD HL,[movedisk.freeplace]
	LD [movedisk.wasfreeplace],HL
	LD HL,[movedisk.curfiledesc]
	LD A,0x0e
	LD E,A
	LD D,0
	ADD HL,DE
	LD A,[HL]
	INC HL
	LD H,[HL]
	LD L,A
	LD [copybody.A.],HL
	LD HL,[movedisk.freeplace]
	LD [copybody.B.],HL
	LD A,[movedisk.count]
	LD [copybody.C.],A
	CALL copybody
	LD [movedisk.freeplace],HL
	LD HL,[movedisk.curfiledesc]
	LD [memcopy.A.],HL
	LD HL,14
	LD [memcopy.B.],HL
	LD HL,[movedisk.freefiledesc]
	LD [memcopy.C.],HL
	CALL memcopy
	LD HL,[movedisk.freefiledesc]
	LD A,0x0e
	LD E,A
	LD D,0
	ADD HL,DE
	LD DE,[movedisk.wasfreeplace]
	LD [HL],E
	INC HL
	LD [HL],D
	LD HL,[movedisk.freefiledesc]
	LD DE,16
	ADD HL,DE
	LD [movedisk.freefiledesc],HL
	LD HL,movedisk.nfiles
	INC [HL]
movedisk.next
	LD HL,[movedisk.curfiledesc]
	LD DE,16
	ADD HL,DE
	LD [movedisk.curfiledesc],HL
	JP movedisk.loop
movedisk.quit
movedisk.E.
	LD HL,[movedisk.freefiledesc]
	LD DE,0
	ADD HL,DE
	LD A,[HL]
	SUB 0x00
	JP Z,movedisk.F.
	LD HL,[movedisk.freefiledesc]
	LD DE,0
	ADD HL,DE
	LD A,0x00
	LD [HL],A
	LD HL,[movedisk.freefiledesc]
	LD DE,16
	ADD HL,DE
	LD [movedisk.freefiledesc],HL
	JP movedisk.E.
movedisk.F.
	LD HL,psystrk
	LD DE,0x8e1
	ADD HL,DE
	LD DE,[movedisk.freeplace]
	LD [HL],E
	INC HL
	LD [HL],D
	LD HL,psystrk
	LD DE,0x8e4
	ADD HL,DE
	LD A,[movedisk.nfiles]
	LD [HL],A
	LD HL,psystrk
	LD DE,0x8e5
	ADD HL,DE
	LD DE,[movedisk.nfreesectors]
	LD [HL],E
	INC HL
	LD [HL],D
	LD HL,psystrk
	LD DE,0x8f4
	ADD HL,DE
	LD A,0x00
	LD [HL],A
	LD HL,psystrk
	LD [writesectors.A.],HL
	LD HL,0x0000
	LD [writesectors.B.],HL
	LD A,0x09
	LD [writesectors.C.],A
	CALL writesectors
	RET
