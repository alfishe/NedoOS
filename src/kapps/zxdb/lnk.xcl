-cZ80
-Ilist
-Z(CODE)RCODE,CODE,CDATA0,CONST,CSTR,CCSTR=0100-FF00
-Z(DATA)DATA0,IDATA0,ECSTR,NO_INIT,CSTACK+274,UDATA0
-e_medium_write=_formatted_write
-e_medium_read=_formatted_read
