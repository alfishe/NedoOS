-cZ80
-Ilist
-Z(CODE)RCODE,CODE,CDATA0,CONST,CSTR,CCSTR=0100-FFF0
-Z(DATA)DATA0,IDATA0,UDATA0,ECSTR,NO_INIT,CSTACK+400
-e_medium_write=_formatted_write
-e_medium_read=_formatted_read
