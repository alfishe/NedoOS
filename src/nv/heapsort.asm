                ;MAIN    "HPTST",#16

                ;working assumptions:

                ;0000..7FFF -- code area
                ;8000..BFFF, C000..FFFF -- page switching area

                ;uses 2 pages for elements, 4 pages for strings
                ;strings are zero-terminated, cant cross page boundary

                ;switches pages on its own
;-------------------------------------------------------------------------------
;-------------------------------------------------------------------------------



HPSRT_init      ;inits everything for a new sort

                LD      HL,#4000
                LD      (HS_s0free),HL
                LD      (HS_s1free),HL
                LD      (HS_s2free),HL
                LD      (HS_s3free),HL

                LD      H,L ;0
                LD      (HS_enum),HL

                RET 

;HS_strpg        DB      #20 ;4 pages for strings
;HS_elpg         DB      #24 ;2 pages for elements

                ;free spaces in string pages
HS_s0free       DW      0
HS_s1free       DW      0
HS_s2free       DW      0
HS_s3free       DW      0

                ;elements array free offset
HS_enum         DW      0 ;working number of elements
HS_num          DW      0 ;final number of elements



HPSRT_mkstr     ;makes new string and checks whether it could be fitted
                ;in mem
                ;
                ;in:  HL - null-terminated string to copy to mem
                ;out: HL - page/offset for a fitted string
                ;out: CY=1 - no space for the string


                ;calc string size (no more than 255)
                PUSH    HL

                LD      BC,1
HS_ms_ssize
                LD      A,(HL)
                INC     HL
                OR      A
                JR      Z,HS_ms_sse

                INC     C
                JR      NZ,HS_ms_ssize

                ;if the string greater than 255 symbols (incl. end-zero)
                POP     HL
                SCF 
                RET 

HS_ms_sse

                ;search for suitable page to fit
                LD      HL,HS_s0free
                LD      A,4
HS_ms_spg
                LD      E,(HL)
                INC     HL
                LD      D,(HL)
                INC     HL

                EXD     ;HL - free size

                OR      A
                SBC     HL,BC
                EXD 
                JR      NC,HS_ms_fndpg

                DEC     A
                JR      NZ,HS_ms_spg
                POP     HL
                SCF 
                RET 

HS_ms_fndpg     ;free space is found

                DEC     HL
                LD      (HL),D
                DEC     HL
                LD      (HL),E ;update free space

                LD      HL,0
                OR      A
                SBC     HL,DE   ;displacement for win3
                OR      A
                SBC     HL,BC ;beginning of space for string

                ;4 3 2 1 to 0 1 2 3
                ;4 3 2 1 - FB FC FD FE - 0 1 2 3
                CPL 
                ADD     A,5
                PUSH    AF ;pg num

                ;LD      B,A
                ;LD      A,(HS_strpg)
                ;ADD     A,B
                PGW3strpg

                EXD 
                POP     HL
                EX      (SP),HL ;restore pointer to string

                PUSH    DE
                ;copy HL->DE with ending zero
                LD      A,(HL)
                LDI 
                OR      A
                JR      NZ,$-4

                POP     HL
                POP     AF

                ;make 16bit offset
                ;HL - 16disp, A - page
                RRCA 
                RRCA 
                XOR     H
                AND     #C0
                XOR     H
                LD      H,A

                RET ;CY=0



HPSRT_add       ;adds new element to heap, keeping heap property
                ;
                ; DEHL -- heap element (DE - dirfile+name, HL - strptr)
                ; D.7 -- 0 for dir, 1 for file
                ; DE.14..0 -- name number in directory, not touched
                ; HL -- offset to the name string, 2 MSB bits is page,
                ;       others is offset
                ;
                ;out: CY=1 - no space for the element
                ;
                ;kills: every reg incl. alternative

                ;check if there is place for new element
                ;max. 8192 els

                EXX 
                LD      HL,(HS_enum)
                INC     HL
                BIT     5,H
                ;JR      Z,$+4
                SCF 
                RET nz ;too many elements

                LD      (HS_enum),HL
                DEC     HL

                PUSH    HL

                ;num2addr
                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PGW3elpg
                LD      A,#C0
                OR      H
                LD      H,A

                EXX 
                LD      A,D
                EXX 
                LD      (HL),A
                INC     L
                EXX 
                LD      A,E
                EXX 
                LD      (HL),A
                INC     L
                EXX 
                LD      A,H
                EXX 
                LD      (HL),A
                INC     L
                EXX 
                LD      A,L
                EXX 
                LD      (HL),A


                POP     HL

                CALL    HPSRT_upswap

                OR      A
                RET 





HPSRT_sort      ;sorts array after all additions finished


                LD      HL,(HS_enum)
                LD      (HS_num),HL  ;final number of elements

HS_s_loop
                LD      HL,(HS_enum)

                ;no sort if no elements
                LD      A,H
                OR      L
                RET     Z

                ;no sort if 1 element
                DEC     HL
                LD      A,H
                OR      L
                RET     Z

                LD      (HS_enum),HL ;1 element less to sort next time

                ;swap last element (in HL) with top

                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PGW3elpg
                LD      A,H
                OR      #C0
                LD      H,A

                LD      DE,#8000
                ;LD      A,(HS_elpg)
                PGW2elpg0

               DUP     3
                LD      A,(DE)
                LD      B,(HL)
                EXD 
                LD      (DE),A
                LD      (HL),B
                INC     E
                INC     L
               EDUP 
                LD      A,(DE)
                LD      B,(HL)
                EXD 
                LD      (DE),A
                LD      (HL),B

                CALL    HPSRT_downswap

                JR      HS_s_loop



                ;do downswap from the root to HS_enum
HPSRT_downswap
                LD      DE,0 ;root

HS_s_dswp_loop
                ;calc left leaf
                LD      H,D
                LD      L,E
                ADD     HL,HL
                INC     HL    ;HL - left leaf

                LD      BC,(HS_enum) ; size of array
                OR      A
                SBC     HL,BC
                RET     NC  ;no leafs

                PUSH    DE

                LD      A,H  ;if result is #FFFF -
                AND     L    ;only left leaf
                ADD     HL,BC
                INC     A
                JR      Z,HS_s_dswp_left

                ;have 2 leafs
                LD      D,H
                LD      E,L
                INC     DE  ;DE - right leaf

                PUSH    HL,DE
                CALL    HPSRT_cmpel
                ;CY=1 - DE is smaller
                ;CY=0 - DE is equal or bigger

                POP     DE,HL
                JR      C,$+3
                EXD 
                ;now in HL is biggest leaf of two

HS_s_dswp_left
                POP     DE ;root
                ;HL is leaf to swap with

                PUSH    HL ;also next root

                CALL    HPSRT_cmpswap

                POP     DE
                JR      C,HS_s_dswp_loop

                RET 





HPSRT_upswap    ;in:  HL - number of leaf element to process
                ; swaps elements up to the root

                LD      A,H
                OR      L
                RET     Z

                ;calc root
                LD      D,H
                LD      E,L
                 dec de
                SRL     D
                RR      E
                ;JR      C,$+3
                ;DEC     DE

                PUSH    DE ;remember root el for possible recursion

                CALL    HPSRT_cmpswap

                ;restore root in HL
                POP     HL

                RET     NC ;exit if no swap

                ;tail recursion
                JR      HPSRT_upswap


HPSRT_cmpswap   ;CY=1 if swap, CY=0 otherwise

                EXD 
                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PUSH    AF ;pg num for root
                PGW2elpg
                ;LD      A,H
                ;AND     #3F
                ;OR      #80
                ;LD      H,A
                res 6,h
                set 7,h
                EXD 

                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PUSH    AF ;pg num for leaf
                PGW3elpg
                LD      A,H
                OR      #C0
                LD      H,A

                CALL    HPSRT_cmp
                ;CY=0 - de is not smaller, no swap

                JR      C,HS_us_swp

                ;no swap - stop
                POP     HL
                POP     HL
                RET 
HS_us_swp
                POP     AF
                PGW3elpg
                POP     AF
                PGW2elpg

               DUP     3
                LD      A,(DE)
                LD      B,(HL)
                EXD 
                LD      (DE),A
                LD      (HL),B
                INC     E
                INC     L
               EDUP 
                LD      A,(DE)
                LD      B,(HL)
                EXD 
                LD      (DE),A
                LD      (HL),B

                SCF 
                RET 



HPSRT_cmpel
                ;in: DE,HL - elements
                ;out: CY=1 if de is smaller, otherwise CY=0

                ;make offsets instead of el numbers, switch pages
                ; 8000-BFFF - for root el (DE)
                ; C000-FFFF - for leaf el (HL)

                EXD 
                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PGW2elpg
                ;LD      A,H
                ;AND     #3F
                ;OR      #80
                ;LD      H,A
                res 6,h
                set 7,h
                EXD 

                ADD     HL,HL
                ADD     HL,HL
                LD      A,H
                RLCA 
                RLCA 
                AND     1
                ;LD      B,A
                ;LD      A,(HS_elpg)
                ;ADD     A,B
                PGW3elpg
                LD      A,H
                OR      #C0
                LD      H,A

HPSRT_cmp       ;compare element pointed by HL
                ; with element pointed by DE

                ;we kill pages in W2 and W3
                ;but retain HL and DE

                ;out: CY=0 - DE is not smaller (may be upper in tree)


                PUSH    DE
                PUSH    HL

                ;compare dir/file, dir is always smaller
                LD      A,(DE)
                XOR     (HL)
                JP      P,HS_cp_str

                ;signs differ: DE must be file to be greater

                LD      A,(HL)
                RLCA 

                POP     HL
                POP     DE
                RET 


HS_cp_str       ;compare strings here

                ;get strings into DE,HL, also paging
                EXD 
                INC     L
                INC     L
                LD      A,(HL)
                INC     L
                LD      L,(HL)
                LD      H,A
                RLCA 
                RLCA 
                AND     3
                ;LD      B,A
                ;LD      A,(HS_strpg)
                ;ADD     A,B
                PGW2strpg
                ;LD      A,H
                ;AND     #3F
                ;OR      #80
                ;LD      H,A
                res 6,h
                set 7,h
                EXD 

                INC     L
                INC     L
                LD      A,(HL)
                INC     L
                LD      L,(HL)
                LD      H,A
                RLCA 
                RLCA 
                AND     3
                ;LD      B,A
                ;LD      A,(HS_strpg)
                ;ADD     A,B
                PGW3strpg
                LD      A,H
                OR      #C0
                LD      H,A

                ;compare strings
HS_cp_strcp     LD      A,(DE)
                CP      (HL)
                JR      NZ,HS_cp_neq

                INC     DE
                INC     HL
                OR      A
                JR      NZ,HS_cp_strcp

                ;cy is clear, DE is not smaller
                POP     HL
                POP     DE
                RET 

HS_cp_neq       ;(DE) must be not smaller,
                ;if so, (DE)-(HL) doesnt gen CY

                POP     HL
                POP     DE
                RET 


