L_4020 = #4020 ;adres levoj bashki zmei
L_403D = #403D ;adres pravoj bashki zmei
L_40A8 = #40A8 ;adres dlya udaleniya nadpesi "PALACE SOFTWARE"
L_40A9 = #40A9 ;adres scheta levogo igroka
L_40AF = #40AF ;adres nadpisi nomera raunda ili tajmera
L_40B2 = #40B2 ;adres scheta pravogo igroka
L_40E2 = #40E2 ;adres nachala chistilki ekrana i vivoda urovnya
L_4845 = #4845 ;adres pervoj v menu stroki
L_4886 = #4886 ;adres vtoroj v menu stroki
L_4896 = #4896 ;!!!!! HZ chto!
L_48A6 = #48A6 ;adres tretej v menu stroki
L_48C6 = #48C6 ;adres 4ortoj v menu stroki
L_48E6 = #48E6 ;!!!!! HZ chto!
L_5006 = #5006 ;adres pyatoj v menu stroki
L_5016 = #5016 ;!!!!! HZ chto!
L_5026 = #5026 ;adres sestoj v menu stroki
L_5036 = #5036 ;!!!!! HZ chto!
L_5046 = #5046 ;adres sedmoj v menu stroki
L_5056 = #5056 ;!!!!! HZ chto!
L_57A2 = #57A2 ;kakojto adres vivoda tenevogo ekrana na ekran
L_57C2 = #57C2 ;!!!!! HZ chto!
L_57E5 = #57E5 ;!!!!! HZ chto!
L_58E2 = #58E2 ;adres atributov gasilki ekrana
L_5940 = #5940 ;!!!!! kakoj-to adres dlya otobrazheniya udarov
L_5945 = #5945 ;adres atributov pervoj v menu stroki
L_5986 = #5986 ;adres atributov ciferok v menu
L_5AC2 = #5AC2 ;kakojto adres chistilki ekrana
L_5AE5 = #5AE5 ;kakojto adres chistilki ekrana
tmirror = #5B00
L_5C08 = #5C08
font88 = #5CA8
L_5E02 = #5E02
L_5E82 = #5E82
;L_6060 = #6060 ;pauza v fadeoff i ochistke ekrana

	;ORG	#4000
	;incbin "incbin/screen.scr"
	;ORG	#6600

	;org #6880
L_6880       DB       #F8,#00,#00,#08,#01,#00,#50,#F7       ;x.....Pw
       DB       #20,#84,#40,#03,#00,#00,#16,#00       ; .@.....
       DB       #84,#A7,#00,#00,#24,#00,#03,#20       ;.'..$.. 
       DB       #60,#00,#00,#0F,#F8,#00,#D2,#C6       ;`...x.RF
       DB       #43,#81,#47,#6D,#FA,#9C,#60,#21       ;C.Gmz.`!
       DB       #AB,#82,#56,#29,#1C,#1A,#A9,#00       ;+.V)..).
       DB       #32,#00,#04,#04,#02,#00,#00,#1F       ;2.......
       DB       #F8,#00,#80,#EE,#08,#23,#FF,#DF       ;x..n.#._
       DB       #C9,#F1,#D0,#47,#12,#41,#10,#24       ;IqPG.A.$
       DB       #D9,#77,#61,#82,#D0,#50,#C6,#66       ;Ywa.PPFf
       DB       #F0,#00,#00,#1F,#D8,#02,#C0,#55       ;p...X.@U
       DB       #80,#80,#12,#CE,#FF,#52,#A2,#5A       ;...N.R"Z
       DB       #08,#0C,#23,#C6,#42,#AF,#D8,#83       ;..#FB/X.
       DB       #43,#42,#5E,#1D,#34,#00,#00,#1F       ;CB^.4...
       DB       #F8,#40,#02,#5A,#CB,#62,#D9,#FF       ;x@.ZKbY.
       DB       #BE,#AF,#F1,#64,#C0,#81,#50,#04       ;>/qd@.P.
       DB       #9B,#F7,#B5,#41,#B5,#2F,#DD,#E4       ;.w5A5/]d
       DB       #10,#00,#00,#1F,#F8,#21,#82,#90       ;....x!..
       DB       #77,#E3,#46,#DF,#7D,#05,#74,#86       ;wcF_}.t.
       DB       #83,#40,#84,#19,#0B,#D8,#A4,#15       ;.@...X$.
       DB       #FB,#EE,#F7,#32,#3C,#00,#80,#1F       ;{nw2<...
       DB       #F8,#02,#83,#46,#2B,#65,#11,#63       ;x..F+e.c
       DB       #BF,#36,#FE,#2C,#15,#CB,#09,#41       ;?6~,.K.A
       DB       #09,#1E,#04,#DA,#CE,#EB,#1D,#C0       ;...ZNk.@
       DB       #90,#02,#00,#1F,#F0,#06,#03,#82       ;....p...
       DB       #6F,#F4,#A9,#F4,#6F,#9F,#C6,#97       ;ot)to.F.
       DB       #86,#CB,#45,#28,#23,#90,#4D,#9F       ;.KE(#.M.
       DB       #15,#44,#2F,#40,#80,#13,#60,#1F       ;.D/@..`.
       DB       #E0,#0D,#55,#1A,#78,#CF,#C1,#2F       ;`.U.xOA/
       DB       #FD,#F7,#B9,#F6,#A5,#FF,#F6,#71       ;}w9v%.vq
       DB       #E3,#7F,#B4,#F2,#5B,#F6,#87,#80       ;c.4r[v..
       DB       #00,#13,#B0,#0F,#E0,#03,#31,#D9       ;..0.`.1Y
       DB       #C0,#C8,#D2,#3F,#2E,#FF,#5F,#4C       ;@HR?.._L
       DB       #E5,#FB,#DA,#73,#8B,#89,#7C,#DE       ;e{Zs..|^
       DB       #E5,#01,#82,#40,#00,#1B,#C0,#07       ;e..@..@.
       DB       #C0,#00,#00,#5C,#45,#D5,#80,#CB       ;@..\EU.K
       DB       #FB,#FF,#EF,#D7,#BB,#EB,#FD,#7F       ;{.oW;k}.
       DB       #4D,#A5,#0B,#7D,#01,#07,#27,#00       ;M%.}..'.
       DB       #5D,#AC,#00,#07,#80,#09,#53,#80       ;],....S.
       DB       #19,#1F,#7A,#DD,#EB,#FF,#C9,#F7       ;..z]k.Iw
       DB       #79,#F7,#B5,#FB,#6F,#8A,#C5,#FE       ;yw5{o.E~
       DB       #92,#8C,#85,#34,#32,#ED,#90,#03       ;...42m..
       DB       #80,#01,#7D,#95,#4C,#23,#96,#FF       ;..}.L#..
       DB       #3F,#FF,#E8,#ED,#62,#DB,#E7,#5B       ;?.hmb[g[
       DB       #EF,#4E,#AF,#BF,#D0,#07,#EE,#6D       ;oN/?P.nm
       DB       #35,#2B,#80,#01,#00,#01,#39,#C6       ;5+....9F
       DB       #A7,#57,#3B,#5C,#FF,#DF,#FF,#33       ;'W;\._.3
       DB       #ED,#CD,#AF,#FD,#BF,#DF,#F9,#FC       ;mM/}?_y|
       DB       #C9,#61,#BB,#AA,#B3,#90,#80,#00       ;Ia;*3...
       DB       #00,#00,#03,#9D,#0F,#D0,#E6,#EF       ;.....Pfo
       DB       #F5,#FD,#E6,#FF,#88,#BF,#FF,#FF       ;u}f..?..
       DB       #3B,#FF,#EE,#A7,#C6,#04,#EB,#D9       ;;.n'F.kY
       DB       #DE,#C2,#00,#00,#00,#00,#01,#91       ;^B......
       DB       #51,#E4,#BF,#FE,#FF,#FF,#D8,#FB       ;Qd?~..X{
       DB       #EB,#37,#FF,#F9,#FD,#FF,#FA,#EF       ;k7.y}.zo
       DB       #4C,#95,#FF,#0E,#AD,#60,#00,#00       ;L...-`..
       DB       #00,#00,#00,#00,#89,#14,#9F,#00       ;........
       DB       #E0,#03,#00,#36,#B5,#FF,#7D,#FF       ;`..65.}.
       DB       #FD,#FF,#FF,#B7,#0D,#E1,#7F,#D2       ;}..7.a.R
       DB       #92,#00,#00,#03,#F0,#00,#00,#45       ;....p..E
       DB       #A7,#E4,#03,#01,#E3,#37,#80,#FA       ;'d..c7.z
       DB       #5B,#FB,#FF,#FF,#FB,#FF,#FB,#DF       ;[{..{.{_
       DB       #FF,#27,#FA,#FF,#0A,#00,#00,#0F       ;.'z.....
       DB       #FF,#00,#00,#89,#07,#8F,#AF,#01       ;....../.
       DB       #C5,#CF,#80,#E7,#FF,#67,#FF,#FF       ;EO.g.g..
       DB       #FF,#FF,#F7,#FE,#DF,#6B,#F2,#48       ;..w~_krH
       DB       #1B,#00,#0E,#F6,#4F,#C0,#00,#24       ;...vO@.$
       DB       #10,#97,#7F,#03,#DB,#E7,#80,#1F       ;....[g..
       DB       #F8,#4B,#FF,#FF,#FF,#FF,#FB,#BB       ;xK....{;
       DB       #BF,#6D,#C9,#00,#00,#00,#7B,#EC       ;?mI...{l
       DB       #57,#BC,#00,#28,#80,#0F,#D3,#03       ;W<.(..S.
       DB       #C6,#EB,#80,#E5,#D9,#FF,#FF,#FF       ;Fk.eY...
       DB       #FF,#FF,#FD,#EE,#FF,#E7,#F0,#00       ;..}n.gp.
       DB       #00,#01,#FC,#F2,#3B,#FF,#C0,#00       ;..|r;.@.
       DB       #40,#89,#73,#03,#CF,#E9,#C0,#56       ;@.s.Oi@V
       DB       #FF,#FB,#FF,#FF,#FF,#FF,#FF,#EF       ;.{.....o
       DB       #FF,#86,#EC,#00,#00,#03,#D8,#E1       ;..l...Xa
       DB       #FF,#B7,#F8,#40,#00,#00,#1E,#03       ;.7x@....
       DB       #F3,#EF,#C0,#EB,#FF,#FF,#FF,#FF       ;so@k....
       DB       #FF,#FF,#FA,#ED,#BA,#F3,#AD,#00       ;..zm:s-.
       DB       #00,#0F,#DF,#2C,#FF,#6F,#FC,#04       ;.._,.o|.
       DB       #02,#B1,#71,#07,#BB,#EE,#E0,#EC       ;.1q.;n`l
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#F6,#F9       ;......vy
       DB       #FB,#79,#F9,#02,#00,#1E,#7A,#FF       ;{yy...z.
       DB       #FF,#9F,#BE,#00,#46,#AE,#FD,#0F       ;..>.F.}.
       DB       #F7,#7F,#E0,#DF,#DB,#FF,#FC,#FF       ;w.`_[.|.
       DB       #FF,#FF,#F5,#F5,#BF,#2F,#EB,#03       ;..uu?/k.
       DB       #00,#3E,#FF,#7F,#BF,#9E,#3F,#80       ;.>..?.?.
       DB       #00,#37,#DF,#0F,#DD,#FF,#F0,#DB       ;.7_.].p[
       DB       #FA,#DD,#FF,#FF,#FF,#FF,#FB,#EF       ;z]....{o
       DB       #DF,#8F,#FA,#54,#00,#32,#3F,#FF       ;_.zT.2?.
       DB       #CF,#FF,#D7,#C0,#0A,#D7,#DB,#1F       ;O.W@.W[.
       DB       #68,#EF,#F8,#DF,#FF,#FF,#FB,#FF       ;hox_..{.
       DB       #FF,#FF,#FA,#FF,#FE,#BF,#AB,#B2       ;..z.~?+2
       DB       #00,#6F,#FF,#ED,#8B,#CA,#DF,#F0       ;.o.m.J_p
       DB       #2F,#FF,#9F,#1F,#E2,#AF,#F8,#3F       ;/...b/x?
       DB       #77,#FF,#7F,#FF,#DF,#FF,#7F,#DD       ;w..._..]
       DB       #FF,#DF,#BB,#C0,#00,#EF,#7B,#D8       ;._;@.o{X
       DB       #81,#79,#77,#38,#09,#AD,#DF,#3F       ;.yw8.-_?
       DB       #C8,#C6,#FC,#47,#5F,#FF,#FF,#FF       ;HF|G_...
       DB       #FF,#FF,#DD,#CE,#F7,#FF,#5F,#80       ;..]Nw._.
       DB       #01,#72,#F6,#E0,#E3,#FD,#FB,#BC       ;.rv`c}{<
       DB       #5A,#E9,#09,#3F,#DD,#46,#FC,#FF       ;Zi.?]F|.
       DB       #DF,#F7,#FF,#FF,#FF,#FF,#FF,#DD       ;_w.....]
       DB       #FE,#DE,#63,#00,#07,#F7,#F7,#88       ;~^c..ww.
       DB       #BB,#EF,#FE,#DE,#2E,#7F,#8D,#3F       ;;o~^...?
       DB       #4C,#C2,#FE,#FF,#EF,#F9,#FF,#7F       ;LB~.oy..
       DB       #FF,#FF,#EF,#FD,#FD,#5F,#A5,#D0       ;..o}}_%P
       DB       #0F,#FF,#FF,#C0,#8C,#FF,#79,#7F       ;...@..y.
       DB       #08,#EB,#BE,#3F,#40,#E2,#FE,#FF       ;.k>?@b~.
       DB       #FD,#FF,#FE,#FB,#FF,#FB,#FF,#AB       ;}.~{.{.+
       DB       #FF,#2F,#D1,#B0,#1F,#7B,#7D,#80       ;./Q0.{}.
       DB       #80,#3A,#FE,#EB,#80,#33,#FE,#3F       ;.:~k.3~?
       DB       #CC,#20,#9F,#00,#00,#00,#00,#00       ;L ......
       DB       #00,#08,#20,#04,#00,#91,#0B,#00       ;.. .....
       DB       #7F,#DF,#E6,#01,#C0,#0D,#D7,#F3       ;._f.@.Ws
       DB       #C0,#15,#FC,#7F,#8D,#08,#7F,#80       ;@.|.....
       DB       #00,#00,#00,#00,#00,#20,#68,#90       ;..... h.
       DB       #C0,#40,#DE,#00,#E7,#FA,#24,#03       ;@@^.gz$.
       DB       #E0,#0D,#B1,#F5,#E0,#09,#CD,#7F       ;`.1u`.M.
       DB       #38,#31,#3F,#80,#81,#00,#00,#00       ;81?.....
       DB       #00,#00,#00,#40,#80,#00,#07,#01       ;...@....
       DB       #99,#F0,#00,#07,#F0,#07,#B7,#7A       ;.p..p.7z
       DB       #30,#19,#CE,#7F,#A4,#21,#3F,#80       ;0.N.$!?.
       DB       #00,#00,#00,#00,#00,#40,#01,#10       ;.....@..
       DB       #04,#00,#8F,#03,#DD,#C6,#48,#0F       ;....]FH.
       DB       #F8,#00,#7E,#85,#B8,#40,#5A,#7F       ;x.~.8@Z.
       DB       #20,#01,#4F,#C0,#A0,#00,#00,#00       ; .O@ ...
       DB       #00,#08,#01,#44,#CC,#08,#9F,#0F       ;...DL...
       DB       #EF,#50,#80,#1F,#FC,#21,#1D,#F6       ;oP..|!.v
       DB       #18,#80,#8D,#FF,#06,#11,#BD,#C0       ;......=@
       DB       #00,#90,#00,#00,#00,#48,#00,#20       ;.....H. 
       DB       #80,#41,#FF,#1F,#DF,#A9,#10,#3F       ;.A.._).?
       DB       #FE,#10,#89,#FF,#CC,#00,#04,#FF       ;~...L...
       DB       #48,#35,#BB,#E0,#B0,#00,#00,#00       ;H5;`0...
       DB       #00,#00,#00,#04,#C0,#10,#3F,#3F       ;....@.??
       DB       #DF,#8C,#00,#7F,#FE,#10,#25,#FF       ;_...~.%.
       DB       #36,#00,#20,#FF,#B6,#91,#CF,#E0       ;6. .6.O`
       DB       #00,#00,#00,#00,#00,#01,#03,#19       ;........
       DB       #D0,#7D,#FB,#7F,#FF,#54,#00,#7F       ;P}{..T..
       DB       #FF,#04,#3F,#FF,#FF,#80,#01,#F9       ;..?....y
       DB       #80,#A4,#16,#F0,#00,#00,#FC,#3F       ;.$.p..|?
       DB       #00,#00,#00,#00,#07,#FF,#C0,#FF       ;......@.
       DB       #F5,#20,#00,#FF,#FF,#00,#B0,#97       ;u ....0.
       DB       #0B,#C0,#01,#FE,#09,#94,#07,#F0       ;.@.~...p
       DB       #00,#00,#F0,#0F,#00,#00,#00,#00       ;..p.....
       DB       #1F,#FF,#FC,#FF,#E4,#04,#00,#FF       ;..|.d...
       DB       #FF,#01,#96,#6A,#7E,#F0,#03,#F6       ;...j~p.v
       DB       #08,#84,#86,#FC,#00,#00,#E0,#07       ;...|..`.
       DB       #00,#00,#00,#00,#7F,#FF,#FF,#39       ;.......9
       DB       #10,#62,#00,#FF,#FF,#02,#0B,#5F       ;.b....._
       DB       #FB,#F8,#07,#EA,#61,#08,#3A,#FE       ;{x.ja.:~
       DB       #00,#00,#C0,#03,#00,#00,#00,#07       ;..@.....
       DB       #FF,#FB,#FF,#C3,#B1,#05,#B0,#FF       ;.{.C1.0.
       DB       #FF,#06,#E6,#8B,#3F,#FE,#0F,#F4       ;..f.?~.t
       DB       #3A,#90,#C5,#FF,#80,#00,#80,#01       ;:.E.....
       DB       #00,#00,#07,#FF,#FF,#E5,#FF,#F4       ;.....e.t
       DB       #70,#EB,#E0,#FF,#FF,#1F,#55,#07       ;pk`...U.
       DB       #C7,#6F,#CF,#D8,#82,#00,#07,#FF       ;GoOX....
       DB       #F0,#00,#80,#01,#00,#00,#3F,#FF       ;p.....?.
       DB       #FF,#92,#FF,#FB,#97,#7E,#98,#FF       ;...{.~..
       DB       #FF,#35,#E6,#63,#51,#E5,#E7,#36       ;.5fcQeg6
       DB       #80,#98,#42,#FF,#FF,#00,#00,#00       ;..B.....
       DB       #00,#01,#FF,#FF,#FF,#75,#FF,#FF       ;.....u..
       DB       #FA,#D5,#82,#FF,#FF,#A0,#0C,#38       ;zU... .8
       DB       #3E,#FB,#B9,#04,#80,#A0,#A1,#FF       ;>{9.. !.
       DB       #FF,#FC,#00,#00,#01,#FF,#FF,#FF       ;.|......
       DB       #FF,#0B,#FF,#FF,#FF,#5A,#34,#FF       ;.....Z4.
       DB       #FE,#46,#30,#00,#0B,#FF,#FF,#80       ;~F0.....
       DB       #80,#01,#84,#4D,#EF,#EF,#F6,#AF       ;...Moov/
       DB       #FF,#68,#EF,#67,#AD,#2F,#9D,#FF       ;.hog-/..
       DB       #7F,#8D,#B8,#7F,#FE,#A1,#00,#60       ;..8.~!.`
       DB       #1B,#3F,#FC,#E0,#28,#00,#94,#F7       ;.?|`(..w
       DB       #75,#BB,#28,#10,#BD,#1F,#F5,#FA       ;u;(.=.uz
       DB       #D3,#F6,#0F,#F6,#F7,#F8,#CA,#7F       ;Sv.vwxJ.
       DB       #FC,#32,#86,#99,#05,#3F,#7F,#F8       ;|2...?.x
       DB       #00,#00,#09,#AD,#DC,#6C,#90,#88       ;...-\l..
       DB       #7D,#3B,#D7,#9F,#C7,#D0,#17,#40       ;};W.GP.@
       DB       #D6,#F9,#50,#3F,#F8,#80,#3C,#00       ;VyP?x.<.
       DB       #82,#AD,#DD,#CE,#00,#00,#05,#43       ;.-]N...C
       DB       #32,#29,#80,#00,#90,#5F,#61,#EE       ;2)..._an
       DB       #41,#16,#C2,#44,#19,#FD,#50,#1F       ;A.BD.}P.
       DB       #E0,#00,#10,#00,#00,#42,#DF,#3D       ;`....B_=
       DB       #B0,#00,#00,#68,#6C,#58,#00,#00       ;0..hlX..
       DB       #01,#7B,#3C,#A4,#80,#A1,#29,#23       ;.{<$.!)#
       DB       #01,#FA,#F2,#07,#C0,#00,#00,#00       ;.zr.@...
       DB       #00,#00,#2A,#87,#FF,#00,#00,#14       ;..*.....
       DB       #A1,#00,#00,#00,#0A,#80,#52,#4B       ;!.....RK
       DB       #40,#00,#04,#00,#0C,#2F,#3C,#03       ;@..../<.
       DB       #00,#22,#20,#00,#00,#00,#00,#24       ;." ....$
       DB       #DB,#E0,#00,#01,#00,#00,#00,#00       ;[`......
       DB       #00,#34,#82,#00,#00,#00,#00,#04       ;.4......
       DB       #10,#20,#27,#00,#00,#30,#00,#00       ;. '..0..
       DB       #00,#00,#00,#00,#05,#B8,#00,#00       ;.....8..
       DB       #00,#00,#00,#00,#00,#01,#08,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #04,#88,#10,#00,#08,#2E,#28,#00       ;......(.
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#60,#11,#00,#40,#00       ;...`..@.
       DB       #24,#08,#08,#00,#00,#00,#00,#00       ;$.......
       DB       #00,#00,#00,#00,#02,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#04,#00,#30       ;.......0
       DB       #36,#00,#00,#00,#08,#08,#D3,#00       ;6.....S.
       DB       #02,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#04,#D5,#80,#00,#00       ;....U...
       DB       #07,#C2,#A0,#00,#00,#00,#02,#10       ;.B .....
       DB       #00,#00,#0A,#10,#00,#00,#00,#00       ;........
       DB       #10,#20,#00,#00,#00,#00,#01,#A0       ;. ..... 
       DB       #28,#40,#0C,#00,#00,#78,#46,#28       ;(@...xF(
       DB       #30,#00,#00,#00,#04,#40,#00,#01       ;0....@..
       DB       #00,#00,#00,#00,#00,#95,#00,#00       ;........
       DB       #00,#00,#07,#14,#CA,#58,#01,#20       ;....JX. 
       DB       #00,#20,#18,#C1,#12,#00,#00,#12       ;. .A....
       DB       #90,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #04,#00,#00,#80,#00,#00,#00,#40       ;.......@
       DB       #00,#00,#00,#00,#00,#90,#07,#90       ;........
       DB       #60,#C4,#00,#09,#43,#F0,#00,#00       ;`D..Cp..
       DB       #00,#02,#02,#00,#00,#06,#00,#24       ;.......$
       DB       #00,#06,#E0,#20,#22,#E0,#00,#10       ;..` "`..
       DB       #00,#00,#01,#60,#13,#00,#00,#75       ;...`...u
       DB       #65,#A4,#40,#00,#00,#60,#00,#00       ;e$@..`..
       DB       #00,#01,#02,#00,#00,#4C,#08,#40       ;.....L.@
       DB       #02,#00,#04,#80,#00,#00,#00,#1F       ;........
       DB       #40,#85,#27,#52,#DE,#13,#01,#00       ;@.'R^...
       DB       #00,#02,#00,#03,#00,#00,#00,#40       ;.......@
       DB       #06,#4B,#C0,#00,#01,#14,#00,#00       ;.K@.....
       DB       #00,#00,#00,#00,#37,#00,#FE,#60       ;....7.~`
       DB       #00,#00,#90,#00,#04,#00,#00,#10       ;........
       DB       #26,#00,#40,#00,#15,#12,#40,#00       ;&.@...@.
       DB       #41,#48,#20,#00,#00,#00,#00,#00       ;AH .....
       DB       #02,#B7,#41,#00,#00,#00,#0D,#00       ;.7A.....
       DB       #82,#40,#00,#38,#00,#00,#80,#00       ;.@.8....
       DB       #01,#66,#80,#00,#D9,#81,#18,#00       ;.f..Y...
       DB       #80,#00,#00,#00,#A1,#02,#CE,#00       ;....!.N.
       DB       #00,#00,#00,#D0,#00,#01,#0B,#80       ;...P....
       DB       #00,#00,#00,#00,#E6,#25,#00,#00       ;....f%..
       DB       #FF,#F5,#00,#00,#00,#00,#00,#01       ;.u......
       DB       #42,#17,#46,#00,#00,#00,#00,#02       ;B.F.....
       DB       #D2,#AC,#00,#00,#00,#00,#00,#01       ;R,......
       DB       #19,#00,#00,#00,#4F,#8B,#20,#40       ;....O. @
       DB       #00,#04,#00,#09,#40,#A9,#80,#16       ;....@)..
       DB       #00,#00,#00,#07,#B2,#40,#20,#02       ;....2@ .
       DB       #08,#00,#00,#0F,#0C,#02,#00,#00       ;........
       DB       #06,#AE,#D0,#08,#14,#00,#00,#01       ;..P.....
       DB       #3F,#68,#81,#C4,#00,#00,#00,#00       ;?h.D....
       DB       #16,#00,#00,#20,#00,#00,#82,#11       ;... ....
       DB       #28,#00,#00,#00,#00,#43,#93,#02       ;(....C..
       DB       #00,#00,#10,#02,#F9,#FF,#C2,#49       ;....y.BI
       DB       #70,#00,#00,#00,#00,#00,#60,#40       ;p.....`@
       DB       #00,#00,#02,#5D,#00,#00,#24,#00       ;...]..$.
       DB       #00,#BB,#D8,#D0,#40,#00,#00,#03       ;.;XP@...
       DB       #92,#12,#FD,#16,#B0,#80,#00,#00       ;..}.0...
       DB       #00,#00,#00,#00,#00,#00,#15,#6A       ;.......j
       DB       #00,#00,#00,#00,#00,#00,#7D,#40       ;......}@
       DB       #00,#88,#08,#07,#06,#00,#37,#BF       ;......7?
       DB       #42,#10,#00,#00,#00,#80,#00,#20       ;B...... 
       DB       #00,#00,#60,#78,#80,#00,#00,#01       ;..`x....
       DB       #00,#05,#B9,#88,#96,#00,#00,#FC       ;..9....|
       DB       #40,#00,#04,#45,#57,#B0,#00,#00       ;@..EW0..
       DB       #00,#09,#00,#00,#00,#01,#02,#00       ;........
       DB       #00,#00,#00,#00,#00,#08,#0F,#4D       ;.......M
       DB       #0C,#80,#81,#68,#00,#00,#02,#90       ;...h....
       DB       #F0,#FC,#00,#00,#00,#00,#00,#00       ;p|......
       DB       #00,#05,#40,#00,#00,#00,#00,#0E       ;..@.....
       DB       #48,#20,#21,#E1,#21,#92,#48,#E0       ;H !a!.H`
       DB       #00,#00,#00,#04,#81,#04,#00,#00       ;........
       DB       #00,#00,#00,#00,#05,#12,#38,#80       ;......8.
       DB       #00,#00,#00,#3A,#11,#1D,#82,#BE       ;...:...>
       DB       #80,#51,#21,#00,#00,#00,#00,#00       ;.Q!.....
       DB       #80,#86,#00,#00,#00,#00,#00,#00       ;........
       DB       #50,#33,#10,#00,#00,#00,#00,#80       ;P3......
       DB       #20,#34,#88,#27,#13,#04,#50,#00       ; 4.'..P.
       DB       #00,#00,#00,#00,#00,#09,#90,#80       ;........
       DB       #00,#00,#00,#00,#13,#28,#80,#00       ;.....(..
       DB       #08,#94,#03,#00,#26,#18,#10,#03       ;....&...
       DB       #C0,#94,#80,#20,#00,#00,#00,#00       ;@.. ....
       DB       #02,#23,#29,#00,#00,#00,#00,#04       ;.#).....
       DB       #05,#21,#00,#00,#00,#06,#08,#00       ;.!......
       DB       #40,#24,#12,#10,#F0,#20,#00,#04       ;@$..p ..
       DB       #00,#00,#00,#00,#00,#41,#36,#A0       ;.....A6 
       DB       #00,#00,#00,#01,#84,#41,#00,#04       ;.....A..
       DB       #00,#15,#E0,#10,#58,#10,#00,#0A       ;..`.X...
       DB       #70,#00,#00,#00,#00,#00,#00,#00       ;p.......
       DB       #00,#08,#25,#40,#00,#00,#00,#00       ;..%@....
       DB       #01,#00,#00,#00,#21,#68,#00,#08       ;....!h..
       DB       #54,#80,#00,#00,#5E,#40,#40,#00       ;T...^@@.
       DB       #00,#00,#00,#00,#00,#04,#00,#20       ;....... 
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #34,#20,#01,#4C,#12,#20,#00,#40       ;4 .L. .@
       DB       #0F,#C1,#00,#00,#04,#00,#00,#00       ;.A......
       DB       #00,#00,#00,#80,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#60,#02,#04,#50       ;....`..P
       DB       #08,#00,#04,#00,#01,#E0,#00,#10       ;.....`..
       DB       #40,#00,#00,#00,#00,#00,#80,#20       ;@...... 
       DB       #00,#00,#00,#00,#00,#00,#00,#05       ;........
       DB       #80,#30,#44,#07,#12,#00,#00,#00       ;.0D.....
       DB       #27,#6A,#04,#00,#02,#00,#00,#00       ;'j......
       DB       #00,#00,#04,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#50,#26,#00,#48,#10,#60       ;..P&.H.`
       DB       #0C,#00,#00,#00,#71,#3D,#80,#00       ;....q=..
       DB       #80,#00,#00,#20,#00,#00,#00,#00       ;... ....
       DB       #00,#00,#00,#00,#00,#00,#00,#38       ;.......8
       DB       #00,#02,#28,#80,#10,#00,#00,#00       ;..(.....
       DB       #01,#45,#20,#02,#00,#00,#02,#00       ;.E .....
       DB       #10,#00,#00,#02,#40,#00,#00,#00       ;....@...
       DB       #00,#00,#64,#60,#01,#A8,#20,#02       ;..d`.( .
       DB       #00,#40,#00,#00,#04,#82,#53,#00       ;.@....S.
       DB       #29,#00,#00,#21,#41,#01,#40,#04       ;)..!A.@.
       DB       #00,#00,#00,#00,#00,#00,#30,#C4       ;......0D
       DB       #44,#90,#00,#04,#3A,#00,#00,#00       ;D...:...
       DB       #00,#08,#DC,#00,#04,#50,#80,#02       ;..\..P..
       DB       #00,#14,#80,#00,#80,#00,#00,#00       ;........
       DB       #00,#00,#CA,#1C,#EB,#00,#00,#00       ;..J.k...
       DB       #10,#00,#00,#00,#00,#02,#1A,#51       ;.......Q
       DB       #82,#00,#06,#80,#3B,#C8,#10,#00       ;....;H..
       DB       #82,#20,#00,#00,#00,#02,#60,#54       ;. ....`T
       DB       #80,#04,#00,#00,#01,#00,#00,#00       ;........
       DB       #00,#80,#D1,#A4,#00,#0A,#03,#2B       ;..Q$...+
       DB       #61,#7A,#D6,#40,#2A,#01,#00,#00       ;azV@*...
       DB       #00,#04,#82,#B8,#C1,#00,#00,#44       ;...8A..D
       DB       #A4,#2E,#04,#02,#00,#18,#0B,#64       ;$......d
       DB       #BA,#09,#46,#EE,#22,#CB,#53,#40       ;:.Fn"KS@
       DB       #E0,#34,#00,#00,#02,#01,#8A,#A8       ;`4.....(
       DB       #92,#00,#00,#04,#A8,#00,#00,#09       ;....(...
       DB       #40,#0A,#C1,#3B,#15,#0D,#ED,#B0       ;@.A;..m0
       DB       #82,#09,#A5,#45,#80,#52,#00,#45       ;..%E.R.E
       DB       #10,#EB,#03,#26,#40,#80,#00,#00       ;.k.&@...
       DB       #01,#A4,#10,#01,#03,#00,#B2,#6E       ;.$....2n
       DB       #EF,#BF,#3B,#62,#00,#71,#08,#64       ;o?;b.q.d
       DB       #67,#3B,#40,#8A,#B7,#02,#4A,#24       ;g;@.7.J$
       DB       #40,#00,#00,#08,#C4,#80,#42,#48       ;@...D.BH
       DB       #98,#46,#8E,#44,#3A,#83,#8C,#02       ;.F.D:...
       DB       #10,#C0,#00,#22,#12,#00,#B0,#91       ;.@."..0.
       DB       #10,#41,#E0,#45,#8A,#10,#00,#07       ;.A`E....
       DB       #80,#68,#80,#02,#CF,#1D,#29,#A1       ;.h..O.)!
       DB       #6F,#92,#6A,#92,#00,#00,#00,#06       ;o.j.....
       DB       #5C,#00,#6C,#6E,#A8,#00,#21,#50       ;\.ln(.!P
       DB       #01,#00,#00,#03,#24,#02,#83,#15       ;....$...
       DB       #32,#47,#C0,#F4,#B9,#00,#00,#45       ;2G@t9..E
       DB       #00,#00,#00,#00,#21,#20,#04,#D5       ;....! .U
       DB       #DA,#84,#95,#24,#91,#80,#00,#23       ;Z..$...#
       DB       #60,#04,#A2,#90,#50,#D2,#96,#00       ;`.".PR..
       DB       #00,#00,#03,#10,#00,#00,#00,#00       ;........
       DB       #18,#08,#A6,#91,#64,#F2,#FF,#81       ;..&.dr..
       DB       #00,#08,#00,#16,#42,#C0,#76,#A0       ;....B@v 
       DB       #05,#C0,#78,#00,#00,#03,#38,#08       ;.@x...8.
       DB       #00,#00,#00,#02,#00,#00,#00,#66       ;.......f
       DB       #81,#20,#A4,#A1,#00,#00,#04,#0C       ;. $!....
       DB       #59,#79,#81,#6B,#EE,#01,#10,#00       ;Yy.kn...
       DB       #00,#00,#01,#04,#10,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#1C,#02,#3D       ;.......=
       DB       #30,#00,#A0,#23,#40,#04,#02,#8C       ;0. #@...
       DB       #9A,#EC,#10,#01,#00,#00,#00,#00       ;.l......
       DB       #00,#00,#00,#00,#00,#00,#00,#04       ;........
       DB       #03,#10,#40,#02,#06,#10,#09,#A6       ;..@....&
       DB       #C6,#13,#0A,#D8,#E6,#84,#29,#B0       ;F..Xf.)0
       DB       #00,#00,#40,#01,#00,#00,#00,#00       ;..@.....
       DB       #00,#08,#00,#A8,#0A,#10,#01,#50       ;...(...P
       DB       #20,#01,#21,#47,#9A,#D4,#68,#D8       ; .!G.ThX
       DB       #11,#50,#42,#00,#E0,#00,#84,#00       ;.PB.`...
       DB       #00,#00,#00,#00,#00,#00,#04,#10       ;........
       DB       #80,#00,#00,#06,#BC,#0E,#11,#99       ;....<...
       DB       #7E,#92,#3E,#48,#01,#80,#00,#00       ;~.>H....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#03       ;........
       DB       #44,#09,#01,#27,#60,#6C,#98,#80       ;D..'`l..
       DB       #0D,#04,#00,#00,#00,#01,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#11,#42,#04,#E6       ;.....B.f
       DB       #66,#8C,#F6,#01,#20,#08,#00,#00       ;f.v. ...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #40,#1B,#57,#59,#F1,#63,#10,#18       ;@.WYqc..
       DB       #21,#08,#00,#00,#00,#00,#00,#00       ;!.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#05,#31,#03       ;......1.
       DB       #C2,#88,#08,#00,#00,#00,#00,#00       ;B.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#1C,#30,#6A,#40,#24,#00       ;...0j@$.
       DB       #00,#10,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#01,#55       ;.......U
       DB       #39,#00,#80,#00,#00,#00,#00,#00       ;9.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#B7,#B6,#01,#20,#00       ;...76. .
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#03,#23       ;.......#
       DB       #0A,#48,#00,#00,#00,#00,#00,#00       ;.H......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#03,#F4,#08,#00,#00,#00       ;...t....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#01,#80,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #14,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#01,#02,#3C,#00,#00,#00       ;....<...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#71       ;.......q
       DB       #26,#00,#00,#00,#00,#00,#00,#00       ;&.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#80,#01,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#01,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #C0,#00,#00,#00,#00,#00,#00,#00       ;@.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#40,#00,#00,#00,#00,#00       ;..@.....
       DB       #00,#40,#00,#00,#E8,#00,#00,#00       ;.@..h...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#A0,#00,#00,#00,#00       ;... ....
       DB       #00,#00,#00,#00,#00,#00,#00,#05       ;........
       DB       #F8,#00,#00,#08,#00,#FF,#FF,#00       ;x.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#7F       ;........
       DB       #FF,#FF,#FF,#0F,#F8,#00,#00,#04       ;....x...
       DB       #A0,#F8,#3F,#00,#00,#00,#00,#00       ; x?.....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#FF,#FF,#FF,#FF,#0F       ;........
       DB       #F8,#00,#00,#00,#C0,#40,#0F,#00       ;x...@@..
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#03,#FF       ;........
       DB       #FF,#FF,#FE,#1F,#F8,#00,#00,#40       ;..~.x..@
       DB       #C0,#00,#07,#00,#00,#00,#00,#00       ;@.......
       DB       #00,#00,#00,#00,#00,#00,#1C,#00       ;........
       DB       #00,#00,#07,#FF,#FF,#FF,#FF,#1F       ;........
       DB       #F8,#00,#00,#00,#E0,#00,#03,#00       ;x...`...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#7F,#E0,#00,#00,#0F,#FF       ;...`....
       DB       #FF,#FF,#54,#1F,#F0,#00,#00,#00       ;..T.p...
       DB       #F8,#00,#03,#00,#00,#00,#00,#00       ;x.......
       DB       #00,#00,#00,#00,#00,#5B,#FF,#FF       ;.....[..
       DB       #00,#00,#0F,#FF,#FF,#FF,#FA,#1F       ;......z.
       DB       #F0,#00,#00,#00,#F8,#00,#01,#00       ;p...x...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #8D,#FF,#FF,#FF,#F5,#00,#1F,#FF       ;....u...
       DB       #FF,#FF,#BE,#1F,#E0,#00,#00,#00       ;..>.`...
       DB       #FC,#00,#00,#00,#00,#00,#00,#00       ;|.......
       DB       #00,#00,#00,#00,#00,#3F,#FF,#FE       ;.....?.~
       DB       #00,#00,#1F,#FF,#FF,#FF,#DF,#0F       ;......_.
       DB       #C0,#00,#00,#00,#80,#00,#00,#E0       ;@......`
       DB       #00,#00,#00,#00,#38,#00,#00,#00       ;....8...
       DB       #00,#00,#0E,#00,#00,#0C,#1F,#FF       ;........
       DB       #CC,#FF,#FB,#0F,#C0,#20,#00,#02       ;L.{.@ ..
       DB       #D0,#60,#00,#FF,#00,#00,#00,#01       ;P`......
       DB       #FF,#80,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#3E,#0F,#FF,#E1,#FF,#FF,#0F       ;.>..a...
       DB       #80,#00,#00,#00,#E1,#F8,#00,#FF       ;....ax..
       DB       #C0,#00,#00,#07,#FF,#E0,#00,#00       ;@....`..
       DB       #00,#00,#00,#00,#00,#3F,#87,#FF       ;.....?..
       DB       #E0,#FF,#FF,#07,#00,#00,#00,#00       ;`.......
       DB       #F9,#FC,#70,#FF,#FC,#00,#00,#17       ;y|p.|...
       DB       #FF,#E1,#F0,#00,#00,#00,#00,#00       ;.ap.....
       DB       #00,#3F,#C3,#FF,#F1,#FF,#FF,#03       ;.?C.q...
       DB       #00,#00,#00,#00,#7B,#FC,#F0,#FF       ;....{|p.
       DB       #FF,#FE,#07,#BA,#FF,#E3,#FC,#00       ;.~.:.c|.
       DB       #00,#00,#00,#00,#00,#7F,#E3,#FF       ;......c.
       DB       #C7,#FF,#FF,#00,#00,#00,#40,#00       ;G.....@.
       DB       #7F,#F9,#F8,#FF,#FF,#FF,#FF,#FF       ;.yx.....
       DB       #FF,#D7,#FF,#80,#00,#00,#00,#38       ;.W.....8
       DB       #00,#7F,#E0,#FF,#9E,#FF,#FF,#00       ;..`.....
       DB       #00,#00,#08,#00,#7F,#FF,#F8,#FF       ;......x.
       DB       #FF,#FF,#FF,#FF,#FE,#FF,#FF,#FF       ;....~...
       DB       #F8,#00,#03,#FF,#E0,#7F,#FF,#FF       ;x...`...
       DB       #FD,#FF,#FF,#00,#00,#00,#02,#00       ;}.......
       DB       #FF,#FF,#FC,#FF,#FF,#FF,#FF,#FF       ;..|.....
       DB       #FF,#FF,#FF,#FF,#FF,#F8,#0F,#FF       ;.....x..
       DB       #FC,#FF,#FF,#7F,#F6,#FF,#FF,#00       ;|...v...
       DB       #E0,#00,#01,#00,#FF,#FF,#FE,#00       ;`.....~.
       DB       #01,#FE,#00,#00,#0F,#80,#00,#1F       ;.~......
       DB       #00,#00,#01,#F8,#FD,#FF,#FF,#BF       ;...x}..?
       DB       #FF,#00,#00,#FC,#C8,#00,#00,#80       ;...|H...
       DB       #FF,#FF,#FF,#80,#03,#FF,#1C,#00       ;........
       DB       #1F,#C3,#C0,#3F,#80,#00,#0F,#FF       ;.C@?....
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#54       ;.......T
       DB       #D0,#00,#00,#00,#FF,#FF,#FF,#80       ;P.......
       DB       #07,#FF,#FF,#00,#3F,#EF,#E0,#7F       ;....?o`.
       DB       #80,#00,#1F,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#50,#00,#F0,#E0,#00,#00,#00       ;.P.p`...
       DB       #FF,#FF,#FF,#E0,#0F,#FF,#FF,#C0       ;...`...@
       DB       #7F,#EF,#E0,#7F,#80,#00,#3F,#FF       ;.o`...?.
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#B2       ;.......2
       DB       #C0,#00,#00,#00,#FF,#FF,#FF,#FE       ;@......~
       DB       #0F,#FF,#FF,#C3,#FF,#FF,#DC,#7F       ;...C..\.
       DB       #00,#03,#1F,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#00,#00,#C4,#A0,#00,#00,#00       ;...D ...
       DB       #FF,#FF,#FF,#FE,#3F,#FF,#FF,#C3       ;...~?..C
       DB       #FF,#FF,#BF,#BF,#80,#07,#9F,#FF       ;..??....
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#A0       ;....... 
       DB       #C4,#00,#00,#08,#FF,#FF,#FF,#FF       ;D.......
       DB       #BF,#FF,#FF,#F7,#FF,#FF,#FF,#FF       ;?..w....
       DB       #CF,#83,#FF,#FF,#FF,#FF,#FF,#FF       ;O.......
       DB       #FF,#80,#10,#D4,#D0,#00,#00,#02       ;...TP...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#C1,#FF,#FF       ;.....A..
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#E8       ;.......h
       DB       #E8,#00,#00,#00,#00,#08,#04,#00       ;h.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #80,#FF,#00,#00,#00,#08,#00,#FF       ;........
       DB       #00,#00,#7F,#E4,#E0,#00,#00,#00       ;...d`...
       DB       #00,#00,#02,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#FF,#00,#00       ;........
       DB       #00,#20,#00,#FF,#00,#00,#EF,#FA       ;. ....oz
       DB       #D0,#00,#00,#00,#80,#00,#01,#00       ;P.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#FF,#00,#00,#00,#00,#00,#FF       ;........
       DB       #00,#00,#4F,#EC,#E9,#00,#01,#00       ;..Oli...
       DB       #40,#00,#01,#00,#00,#00,#00,#00       ;@.......
       DB       #00,#00,#00,#00,#01,#FF,#00,#00       ;........
       DB       #00,#60,#00,#FF,#00,#00,#BB,#54       ;.`....;T
       DB       #F0,#00,#00,#80,#10,#00,#00,#80       ;p.......
       DB       #00,#00,#00,#00,#00,#00,#40,#00       ;......@.
       DB       #00,#FF,#00,#00,#00,#00,#00,#FF       ;........
       DB       #00,#00,#5F,#C8,#FA,#20,#00,#00       ;.._Hz ..
       DB       #04,#00,#01,#00,#00,#00,#00,#00       ;........
       DB       #01,#00,#00,#00,#00,#FF,#00,#00       ;........
       DB       #00,#D0,#00,#FF,#00,#00,#BD,#62       ;.P....=b
       DB       #F5,#00,#00,#40,#00,#00,#00,#A8       ;u..@...(
       DB       #00,#00,#80,#00,#00,#02,#00,#00       ;........
       DB       #00,#FF,#00,#00,#00,#40,#00,#FF       ;.....@..
       DB       #00,#01,#AA,#08,#FA,#40,#00,#20       ;..*.z@. 
       DB       #00,#00,#03,#80,#00,#00,#00,#80       ;........
       DB       #00,#00,#04,#00,#00,#FF,#00,#00       ;........
       DB       #00,#80,#00,#FF,#00,#44,#54,#00       ;.....DT.
       DB       #80,#00,#00,#00,#00,#00,#01,#B5       ;.......5
       DB       #30,#02,#00,#00,#40,#80,#00,#02       ;0...@...
       DB       #00,#00,#00,#00,#00,#A0,#00,#00       ;..... ..
       DB       #00,#01,#6C,#01,#C0,#A0,#00,#40       ;..l.@ .@
       DB       #00,#00,#8B,#F2,#60,#01,#48,#00       ;...r`.H.
       DB       #04,#08,#A0,#01,#00,#00,#00,#00       ;.. .....
       DB       #00,#40,#20,#00,#20,#40,#2A,#03       ;.@ . @*.
       DB       #E0,#C4,#09,#00,#00,#00,#03,#DF       ;`D....._
       DB       #A0,#21,#20,#08,#00,#14,#00,#00       ; ! .....
       DB       #00,#00,#00,#00,#00,#68,#04,#20       ;.....h. 
       DB       #01,#0A,#F4,#07,#F0,#80,#10,#84       ;..t.p...
       DB       #A6,#80,#4F,#EE,#80,#40,#F5,#01       ;&.On.@u.
       DB       #50,#2C,#80,#00,#20,#00,#00,#00       ;P,.. ...
       DB       #05,#3A,#80,#08,#84,#A5,#BA,#0F       ;.:...%:.
       DB       #F8,#4A,#00,#20,#82,#00,#1D,#BC       ;xJ. ...<
       DB       #E0,#20,#29,#E5,#A9,#AA,#00,#00       ;` )e)*..
       DB       #00,#00,#00,#00,#00,#3A,#29,#02       ;.....:).
       DB       #29,#12,#54,#1F,#FC,#E6,#8A,#99       ;).T.|f..
       DB       #59,#80,#17,#EF,#E0,#00,#17,#52       ;Y..o`..R
       DB       #68,#5D,#40,#80,#00,#00,#00,#00       ;h]@.....
       DB       #00,#6C,#A5,#54,#E6,#A4,#B8,#3F       ;.l%Tf$8?
       DB       #FE,#F7,#D7,#A4,#18,#80,#3F,#F9       ;~wW$..?y
       DB       #D0,#20,#01,#E5,#B6,#E0,#C0,#00       ;P .e6`@.
       DB       #00,#00,#00,#10,#41,#39,#92,#95       ;....A9..
       DB       #16,#90,#F8,#7F,#FE,#ED,#FF,#EE       ;..x.~m.n
       DB       #97,#E4,#5F,#7F,#E0,#20,#27,#E6       ;.d_.` 'f
       DB       #AD,#B5,#F0,#80,#00,#00,#00,#00       ;-5p.....
       DB       #08,#FD,#2F,#4B,#6D,#20,#B4,#7F       ;.}/Km 4.
       DB       #FF,#D2,#D9,#AA,#BD,#BF,#FC,#DC       ;.RY*=?|\
       DB       #F0,#08,#07,#C5,#CC,#4F,#B2,#00       ;p..ELO2.
       DB       #00,#00,#01,#00,#02,#96,#5C,#F6       ;......\v
       DB       #B3,#A5,#F0,#FF,#FF,#E6,#EA,#D5       ;3%p..fjU
       DB       #3E,#D7,#F0,#58,#E4,#05,#03,#4D       ;>WpXd..M
       DB       #38,#A4,#F2,#22,#01,#00,#00,#20       ;8$r"... 
       DB       #16,#B6,#A9,#5D,#08,#00,#E4,#FF       ;.6)]..d.
       DB       #FF,#DB,#FB,#F1,#5D,#33,#C1,#C0       ;.[{q]3A@
       DB       #F8,#00,#03,#EF,#52,#96,#50,#00       ;x..oR.P.
       DB       #10,#22,#02,#04,#2D,#4F,#B2,#6B       ;."..-O2k
       DB       #93,#49,#F0,#FF,#FF,#DB,#F6,#5B       ;.Ip..[v[
       DB       #BA,#C6,#07,#1D,#F0,#40,#41,#F8       ;:F..p@Ax
       DB       #28,#D8,#A8,#95,#01,#20,#02,#00       ;(X(.. ..
       DB       #97,#A5,#EF,#DE,#EA,#44,#EA,#FF       ;.%o^jDj.
       DB       #FF,#FD,#EF,#E5,#78,#08,#07,#98       ;.}oex...
       DB       #D5,#29,#01,#97,#6B,#7A,#D4,#20       ;U)..kzT 
       DB       #49,#45,#04,#22,#49,#11,#F5,#75       ;IE."I.uu
       DB       #8C,#98,#50,#FF,#FF,#96,#F9,#F3       ;..P...ys
       DB       #74,#10,#1F,#48,#C9,#16,#03,#D9       ;t..HI..Y
       DB       #95,#B4,#E8,#B5,#62,#B2,#4C,#50       ;.4h5b2LP
       DB       #55,#84,#EE,#EF,#B0,#66,#E4,#FF       ;U.no0fd.
       DB       #FF,#AF,#EE,#EB,#E8,#00,#1F,#A5       ;./nkh..%
       DB       #FA,#85,#06,#7F,#EA,#E4,#D9,#D5       ;z...jdYU
       DB       #7D,#6D,#1A,#3D,#B2,#91,#FB,#FD       ;}m.=2.{}
       DB       #DA,#BD,#F0,#FF,#FF,#DF,#F5,#FE       ;Z=p.._u~
       DB       #70,#00,#3F,#DB,#FF,#AF,#86,#7D       ;p.?[./.}
       DB       #F7,#EA,#6D,#74,#DB,#9A,#BB,#FE       ;wjmt[.;~
       DB       #DB,#43,#FF,#FF,#7F,#6F,#5C,#FF       ;[C...o\.
       DB       #FE,#FF,#A1,#FC,#6A,#00,#EB,#65       ;~.!|j.ke
       DB       #FF,#F0,#DF,#FF,#EF,#D4,#BB,#BF       ;.p_.oT;?
       DB       #08,#D4,#FF,#BF,#0A,#82,#BF,#DF       ;.T.?..?_
       DB       #FE,#FB,#B0,#7F,#FE,#FF,#63,#FC       ;~{0.~.c|
       DB       #60,#01,#C0,#FF,#F0,#E1,#FB,#FF       ;`.@.pa{.
       DB       #7D,#AA,#72,#D7,#01,#B5,#DF,#5F       ;}*rW.5__
       DB       #84,#21,#9E,#EF,#F5,#7F,#EA,#7F       ;.!.ou.j.
       DB       #FC,#FE,#83,#FC,#50,#03,#80,#3F       ;|~.|P..?
       DB       #A0,#45,#6B,#DE,#DF,#2C,#4C,#59       ; Ek^_,LY
       DB       #89,#6A,#DD,#AF,#14,#0A,#CF,#E7       ;.j]/..Og
       DB       #F9,#7F,#B4,#3F,#F8,#FB,#07,#F8       ;y.4?x{.x
       DB       #60,#0F,#D4,#05,#C0,#81,#44,#EE       ;`.T.@.Dn
       DB       #22,#A5,#19,#57,#80,#D7,#9A,#93       ;"%.W.W..
       DB       #6C,#AD,#E3,#77,#FE,#3F,#50,#1F       ;l-cw~?P.
       DB       #E0,#FC,#07,#C0,#D0,#07,#A0,#27       ;`|.@P. '
       DB       #A0,#82,#91,#DC,#7B,#32,#48,#28       ; ..\{2H(
       DB       #D0,#AB,#B8,#27,#85,#43,#F0,#F7       ;P+8'.Cpw
       DB       #78,#1F,#BA,#07,#C0,#D0,#0F,#00       ;x.:.@P..
       DB       #A0,#03,#E2,#83,#E0,#01,#A6,#5F       ; .b.`.&_
       DB       #F1,#01,#56,#05,#88,#DF,#3C,#0B       ;q.V.._<.
       DB       #E8,#95,#78,#36,#9C,#07,#6C,#03       ;h.x6..l.
       DB       #00,#A8,#1E,#01,#C0,#03,#FC,#8B       ;.(..@.|.
       DB       #60,#02,#DF,#5B,#8F,#C3,#80,#57       ;`._[.C.W
       DB       #90,#EF,#78,#03,#D2,#AB,#1E,#03       ;.ox.R+..
       DB       #56,#03,#1A,#00,#00,#50,#3C,#07       ;V....P<.
       DB       #80,#03,#D7,#77,#C0,#03,#FF,#55       ;..Ww@..U
       DB       #90,#FF,#6D,#7D,#D1,#FF,#78,#05       ;..m}Q.x.
       DB       #F9,#77,#9F,#82,#A3,#00,#0C,#00       ;yw..#...
       DB       #F9,#80,#7E,#0E,#C0,#03,#FF,#FF       ;y.~.@...
       DB       #C0,#07,#CE,#14,#00,#7F,#FF,#DF       ;@.N...._
       DB       #40,#09,#D4,#03,#FC,#EE,#8F,#43       ;@.T.|n.C
       DB       #CB,#80,#16,#FF,#E6,#00,#FA,#0F       ;K...f.z.
       DB       #80,#03,#ED,#B5,#E0,#03,#3C,#3C       ;..m5`.<<
       DB       #00,#FB,#FF,#9F,#80,#07,#80,#01       ;.{......
       DB       #E0,#BB,#4F,#A1,#7F,#C0,#08,#BF       ;`;O!.@.?
       DB       #FC,#01,#D4,#1F,#C1,#03,#56,#4B       ;|.T.A.VK
       DB       #A0,#02,#F8,#70,#00,#FF,#FF,#8F       ; .xp....
       DB       #90,#1F,#80,#03,#83,#55,#47,#70       ;.....UGp
       DB       #BF,#E0,#01,#6F,#D0,#03,#F4,#77       ;?`.oP.tw
       DB       #02,#83,#AC,#A5,#C0,#07,#78,#70       ;..,%@.xp
       DB       #01,#FF,#FF,#CF,#88,#FF,#00,#00       ;...O....
       DB       #06,#20,#A7,#58,#3D,#78,#00,#5F       ;. 'X=x._
       DB       #EC,#03,#D8,#F7,#41,#01,#40,#41       ;l.XwA.@A
       DB       #A0,#03,#E1,#F0,#41,#DA,#DF,#C4       ; .apAZ_D
       DB       #40,#7F,#C0,#00,#0C,#84,#22,#AC       ;@.@...",
       DB       #18,#2C,#00,#2F,#D0,#07,#F1,#EB       ;.,./P.qk
       DB       #80,#01,#A2,#08,#C0,#03,#C1,#E0       ;..".@.A`
       DB       #01,#F5,#67,#F0,#08,#7E,#E0,#00       ;.ugp.~`.
       DB       #08,#00,#30,#0A,#04,#5E,#00,#2E       ;..0..^..
       DB       #E0,#0F,#B0,#D7,#80,#01,#00,#02       ;`.0W....
       DB       #40,#0F,#03,#F0,#83,#E8,#2A,#FC       ;@..p.h*|
       DB       #00,#75,#78,#02,#30,#00,#10,#05       ;.ux.0...
       DB       #00,#0B,#00,#55,#F0,#1B,#A0,#E3       ;...Up. c
       DB       #20,#81,#80,#00,#C0,#10,#03,#60       ; ...@..`
       DB       #01,#A0,#80,#B6,#00,#68,#B4,#01       ;. .6.h4.
       DB       #E0,#00,#10,#03,#80,#05,#00,#2B       ;`......+
       DB       #C0,#0B,#D8,#CF,#01,#01,#00,#00       ;@.XO....
       DB       #80,#00,#06,#68,#21,#D2,#24,#5F       ;...h!R$_
       DB       #80,#70,#10,#01,#C0,#00,#08,#02       ;.p..@...
       DB       #E0,#07,#80,#07,#E0,#03,#E4,#E7       ;`...`.dg
       DB       #82,#01,#00,#00,#C0,#00,#0E,#70       ;....@..p
       DB       #00,#A5,#00,#A7,#80,#20,#30,#10       ;.%.'. 0.
       DB       #80,#00,#06,#80,#F0,#03,#C0,#0B       ;....p.@.
       DB       #F0,#03,#A0,#DB,#01,#00,#80,#01       ;p. [....
       DB       #00,#00,#1C,#60,#21,#D0,#28,#0B       ;...`!P(.
       DB       #80,#20,#18,#00,#80,#00,#03,#00       ;. ......
       DB       #68,#02,#C0,#05,#D0,#03,#C2,#EF       ;h.@.P.Bo
       DB       #80,#00,#80,#01,#80,#00,#38,#70       ;......8p
       DB       #41,#E8,#45,#03,#80,#20,#08,#00       ;AhE.. ..
       DB       #80,#00,#01,#00,#1E,#03,#A0,#01       ;...... .
       DB       #F4,#01,#E1,#FF,#42,#80,#80,#01       ;t.a.B...
       DB       #40,#00,#F0,#A0,#01,#C0,#28,#55       ;@.p .@(U
       DB       #00,#20,#08,#00,#40,#00,#01,#00       ;. ..@...
       DB       #2D,#41,#C0,#07,#E0,#09,#91,#FF       ;-A@.`...
       DB       #80,#00,#40,#01,#80,#03,#C0,#25       ;..@...@%
       DB       #41,#00,#00,#23,#04,#20,#0A,#20       ;A..#. . 
       DB       #40,#00,#01,#00,#0E,#01,#80,#02       ;@.......
       DB       #D0,#01,#C1,#EE,#01,#00,#40,#02       ;P.An..@.
       DB       #02,#07,#22,#70,#60,#88,#80,#0B       ;.."p`...
       DB       #00,#20,#08,#00,#20,#00,#01,#02       ;. .. ...
       DB       #14,#01,#C0,#07,#E0,#01,#C1,#FC       ;..@.`.A|
       DB       #02,#80,#40,#01,#00,#0E,#00,#C0       ;..@....@
       DB       #80,#D1,#24,#05,#00,#20,#06,#00       ;.Q$.. ..
       DB       #20,#00,#03,#02,#0C,#02,#80,#05       ; .......
       DB       #C0,#41,#A1,#F8,#01,#80,#40,#02       ;@A!x..@.
       DB       #00,#1C,#2A,#80,#40,#40,#41,#03       ;..*.@@A.
       DB       #00,#20,#04,#10,#10,#00,#02,#00       ;. ......
       DB       #1C,#01,#80,#83,#E0,#01,#C0,#E8       ;....`.@h
       DB       #0D,#C0,#20,#03,#02,#38,#01,#80       ;.@ ..8..
       DB       #A8,#61,#00,#03,#00,#20,#05,#10       ;(a... ..
       DB       #10,#00,#06,#02,#0C,#03,#80,#85       ;........
       DB       #C0,#01,#E0,#F4,#07,#A0,#10,#02       ;@.`t. ..
       DB       #00,#18,#1A,#00,#A0,#20,#25,#05       ;....  %.
       DB       #00,#10,#06,#00,#10,#00,#0C,#00       ;........
       DB       #18,#02,#80,#07,#E0,#41,#C8,#D0       ;....`AHP
       DB       #1F,#D0,#08,#06,#00,#08,#03,#00       ;.P......
       DB       #40,#30,#00,#03,#00,#10,#04,#00       ;@0......
       DB       #10,#00,#08,#02,#08,#01,#80,#87       ;........
       DB       #D0,#01,#E0,#E8,#35,#7C,#04,#05       ;P.`h5|..
       DB       #00,#18,#06,#00,#E0,#19,#00,#01       ;....`...
       DB       #04,#08,#06,#08,#00,#00,#08,#01       ;........
       DB       #18,#02,#80,#83,#C0,#00,#E0,#FB       ;....@.`{
       DB       #4E,#2E,#80,#06,#04,#08,#18,#01       ;N.......
       DB       #38,#04,#00,#02,#00,#08,#05,#10       ;8.......
       DB       #08,#00,#08,#02,#08,#01,#80,#03       ;........
       DB       #A0,#20,#F0,#F6,#90,#8B,#C2,#08       ;  pv..B.
       DB       #00,#28,#00,#14,#84,#00,#00,#04       ;.(......
       DB       #04,#08,#06,#08,#00,#00,#10,#05       ;........
       DB       #18,#02,#80,#00,#E0,#00,#E0,#EA       ;....`.`j
       DB       #24,#20,#E8,#0C,#04,#14,#40,#60       ;$ h...@`
       DB       #22,#00,#00,#08,#00,#04,#05,#00       ;".......
       DB       #04,#00,#00,#06,#38,#01,#80,#07       ;....8...
       DB       #C0,#00,#D0,#74,#80,#92,#05,#08       ;@.Pt....
       DB       #00,#0D,#07,#05,#00,#C0,#00,#00       ;.....@..
       DB       #0C,#82,#06,#00,#04,#00,#60,#0B       ;......`.
       DB       #50,#00,#80,#07,#E0,#00,#E0,#7A       ;P...`.`z
       DB       #20,#00,#50,#50,#0A,#04,#08,#00       ; .PP....
       DB       #48,#18,#00,#00,#2B,#03,#02,#80       ;H...+...
       DB       #02,#00,#80,#2F,#B0,#03,#80,#02       ;.../0...
       DB       #C0,#20,#F0,#28,#12,#20,#02,#18       ;@ p(. ..
       DB       #00,#02,#A2,#44,#00,#40,#A8,#80       ;.."D.@(.
       DB       #00,#01,#03,#02,#02,#01,#80,#7F       ;........
       DB       #F0,#0A,#80,#43,#E0,#00,#68,#34       ;p..C`.h4
       DB       #80,#00,#00,#20,#04,#01,#50,#00       ;... ..P.
       DB       #20,#00,#00,#00,#00,#00,#82,#00       ; .......
       DB       #01,#06,#02,#FF,#F0,#2F,#00,#40       ;....p/.@
       DB       #F0,#00,#70,#1E,#00,#00,#00,#30       ;p.p....0
       DB       #08,#01,#A0,#00,#00,#00,#00,#00       ;.. .....
       DB       #00,#00,#0C,#01,#21,#50,#0F,#F4       ;....!P.t
       DB       #70,#17,#80,#47,#E0,#20,#68,#0D       ;p..G` h.
       DB       #20,#00,#00,#20,#2A,#00,#80,#00       ; .. *...
       DB       #00,#00,#00,#00,#00,#00,#30,#01       ;......0.
       DB       #00,#E0,#B6,#80,#20,#1E,#80,#C7       ;.`6. ..G
       DB       #D0,#20,#70,#07,#80,#00,#00,#40       ;P p....@
       DB       #17,#00,#20,#20,#00,#00,#00,#00       ;..  ....
       DB       #00,#00,#40,#02,#80,#74,#00,#12       ;..@..t..
       DB       #40,#07,#80,#47,#E8,#40,#7A,#01       ;@..Gh@z.
       DB       #50,#00,#00,#82,#5E,#C0,#10,#00       ;P...^@..
       DB       #02,#00,#00,#00,#00,#01,#80,#0D       ;........
       DB       #80,#20,#00,#80,#40,#3F,#80,#63       ;. ..@?.c
       DB       #E0,#00,#3C,#00,#C8,#00,#01,#00       ;`.<.H...
       DB       #6B,#A4,#48,#00,#00,#00,#00,#00       ;k$H.....
       DB       #00,#20,#40,#16,#20,#10,#00,#09       ;. @. ...
       DB       #40,#0D,#80,#27,#D0,#40,#36,#80       ;@..'P@6.
       DB       #60,#00,#06,#01,#FD,#F0,#1E,#00       ;`...}p..
       DB       #00,#00,#00,#00,#00,#02,#08,#80       ;........
       DB       #88,#08,#80,#00,#60,#3B,#80,#47       ;....`;.G
       DB       #E0,#20,#1F,#80,#38,#00,#28,#89       ;` ..8.(.
       DB       #D2,#9C,#01,#00,#00,#00,#00,#00       ;R.......
       DB       #22,#10,#82,#09,#21,#08,#00,#00       ;"...!...
       DB       #80,#09,#80,#27,#F0,#40,#9F,#D8       ;...'p@.X
       DB       #14,#40,#02,#57,#0C,#05,#24,#A0       ;.@.W..$ 
       DB       #00,#00,#00,#00,#00,#00,#08,#00       ;........
       DB       #00,#00,#00,#00,#80,#0B,#80,#CF       ;.......O
       DB       #D0,#00,#7A,#B7,#0C,#05,#65,#00       ;P.z7..e.
       DB       #8A,#53,#44,#24,#00,#00,#00,#00       ;.SD$....
       DB       #00,#00,#00,#00,#00,#00,#00,#01       ;........
       DB       #00,#37,#00,#3F,#C0,#40,#3D,#4A       ;.7.?@@=J
       DB       #A1,#10,#08,#08,#20,#00,#50,#88       ;!... .P.
       DB       #B4,#80,#00,#00,#00,#00,#00,#00       ;4.......
       DB       #00,#00,#00,#02,#01,#4F,#00,#97       ;.....O..
       DB       #E0,#40,#0E,#01,#44,#02,#01,#00       ;`@..D...
       DB       #09,#10,#80,#80,#00,#00,#20,#20       ;......  
       DB       #00,#00,#00,#00,#00,#00,#00,#04       ;........
       DB       #00,#EF,#00,#E7,#E0,#20,#0E,#00       ;.o.g` ..
       DB       #12,#00,#00,#01,#20,#00,#24,#00       ;.... .$.
       DB       #00,#00,#00,#00,#02,#80,#00,#00       ;........
       DB       #00,#00,#00,#08,#03,#C7,#00,#7F       ;.....G..
       DB       #E0,#60,#07,#00,#00,#00,#00,#00       ;``......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#10       ;........
       DB       #04,#BF,#01,#57,#C0,#10,#07,#80       ;.?.W@...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#40,#00,#00,#00,#00,#00       ;..@.....
       DB       #00,#00,#00,#60,#13,#9E,#00,#97       ;...`....
       DB       #C0,#68,#01,#C0,#00,#00,#00,#00       ;@h.@....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#03,#80       ;........
       DB       #4F,#7E,#00,#FB,#C0,#B4,#00,#E0       ;O~.{@4.`
       DB       #00,#00,#00,#20,#00,#00,#00,#00       ;... ....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#0C,#00,#27,#76,#00,#5F       ;....'v._
       DB       #C1,#78,#00,#70,#00,#00,#00,#00       ;Ax.p....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#10,#01       ;........
       DB       #1E,#7E,#00,#F7,#C6,#FE,#00,#38       ;.~.wF~.8
       DB       #00,#00,#00,#08,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#20,#16,#69,#3C,#00,#7F       ;.. .i<..
       DB       #E3,#FD,#40,#18,#00,#00,#00,#00       ;c}@.....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#45,#49       ;......EI
       DB       #92,#08,#00,#7F,#FF,#AE,#B0,#0C       ;......0.
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#02,#00,#34,#08,#A8,#00,#7F       ;...4.(..
       DB       #EE,#FB,#E8,#06,#00,#00,#00,#00       ;n{h.....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#50,#80       ;......P.
       DB       #40,#10,#02,#F7,#FF,#FF,#FC,#02       ;@..w..|.
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#10,#00,#02,#00,#20,#01,#FF       ;..... ..
       DB       #FF,#51,#3E,#01,#00,#00,#00,#00       ;.Q>.....
       DB       #02,#00,#00,#40,#00,#00,#00,#00       ;...@....
       DB       #00,#00,#00,#00,#00,#01,#00,#10       ;........
       DB       #00,#40,#4F,#DF,#F8,#84,#0F,#91       ;.@O_x...
       DB       #10,#04,#40,#00,#00,#00,#00,#00       ;..@.....
       DB       #00,#00,#00,#08,#00,#00,#00,#00       ;........
       DB       #08,#00,#20,#00,#00,#00,#0B,#FF       ;.. .....
       DB       #E2,#10,#A3,#68,#81,#00,#00,#00       ;b.#h....
       DB       #00,#80,#00,#00,#00,#00,#80,#00       ;........
       DB       #00,#00,#00,#00,#01,#14,#00,#00       ;........
       DB       #01,#80,#5F,#FF,#88,#44,#00,#02       ;.._..D..
       DB       #24,#20,#00,#00,#41,#00,#00,#80       ;$ ..A...
       DB       #00,#21,#00,#00,#20,#00,#00,#00       ;.!.. ...
       DB       #00,#00,#00,#00,#02,#04,#BD,#FF       ;......=.
       DB       #A1,#00,#10,#80,#02,#00,#02,#12       ;!.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #10,#00,#00,#00,#00,#00,#04,#00       ;........
       DB       #04,#21,#F9,#6B,#60,#01,#00,#08       ;.!yk`...
       DB       #80,#40,#00,#00,#00,#00,#00,#00       ;.@......
       DB       #00,#00,#00,#00,#20,#00,#00,#08       ;.... ...
       DB       #00,#00,#04,#00,#22,#5F,#E7,#93       ;...."_g.
       DB       #C8,#00,#00,#00,#00,#00,#00,#00       ;H.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #81,#FF,#8F,#D5,#9D,#70,#00,#00       ;...U.p..
       DB       #00,#00,#08,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#0A,#00,#07,#FE,#05,#63       ;.....~.c
       DB       #F3,#80,#00,#00,#00,#00,#00,#00       ;s.......
       DB       #01,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #7F,#D8,#78,#97,#D6,#00,#0F,#00       ;.Xx.V...
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#12,#D4,#00,#05,#7D       ;....T..}
       DB       #F8,#01,#40,#A0,#00,#00,#00,#40       ;x.@ ...@
       DB       #08,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#40,#30,#00       ;.....@0.
       DB       #00,#00,#01,#F7,#80,#00,#00,#10       ;...w....
       DB       #00,#00,#10,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#5F       ;......._
       DB       #F0,#00,#00,#02,#00,#00,#28,#00       ;p.....(.
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#40,#30,#00       ;.....@0.
       DB       #00,#00,#00,#05,#C6,#80,#00,#08       ;....F...
       DB       #00,#00,#02,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#3F,#C0,#03,#FF       ;....?@..
       DB       #FC,#00,#FF,#F0,#03,#3F,#CC,#03       ;|..p.?L.
       DB       #FF,#FC,#0F,#F0,#FF,#0C,#0F,#03       ;.|.p....
       DB       #00,#FF,#F0,#00,#3F,#C0,#00,#00       ;..p.?@..
       DB       #00,#00,#00,#30,#00,#01,#50,#00       ;...0..P.
       DB       #02,#B0,#00,#03,#F8,#00,#03,#F8       ;.0..x..x
       DB       #00,#01,#F8,#00,#01,#FC,#00,#00       ;..x..|..
       DB       #FC,#00,#00,#FE,#00,#00,#7E,#00       ;|..~..~.
       DB       #00,#7E,#00,#00,#7F,#00,#00,#3F       ;.~.....?
       DB       #00,#00,#3F,#00,#00,#00,#00,#00       ;..?.....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#3F,#C0,#03,#FF,#FC,#00,#FF       ;.?@..|..
       DB       #F0,#03,#3F,#CC,#03,#F0,#FC,#0F       ;p.?L.p|.
       DB       #C0,#3F,#0C,#C0,#33,#00,#80,#10       ;@?.@3...
       DB       #01,#06,#08,#00,#C0,#30,#00,#F0       ;....@0.p
       DB       #F8,#00,#3F,#C8,#00,#0F,#08,#00       ;x.?H....
       DB       #00,#AC,#00,#00,#5C,#00,#00,#FC       ;.,..\..|
       DB       #00,#00,#3C,#00,#00,#7E,#00,#00       ;..<..~..
       DB       #7E,#00,#00,#7E,#00,#00,#7E,#00       ;~..~..~.
       DB       #00,#7E,#00,#00,#3E,#00,#00,#3E       ;.~..>..>
       DB       #00,#00,#3E,#00,#00,#3F,#00,#00       ;..>..?..
       DB       #00,#00,#00,#00,#00,#03,#3F,#00       ;......?.
       DB       #0F,#FF,#C0,#0F,#FF,#00,#3F,#FE       ;..@...?~
       DB       #30,#3C,#3C,#F0,#0C,#0F,#38,#0E       ;0<<p..8.
       DB       #0F,#F8,#08,#0B,#FC,#08,#88,#FC       ;.x..|..|
       DB       #08,#08,#FC,#00,#20,#3E,#00,#20       ;..|. >. 
       DB       #3E,#00,#00,#32,#00,#03,#F6,#00       ;>..2..v.
       DB       #FF,#CA,#00,#3F,#96,#00,#00,#2F       ;.J.?.../
       DB       #00,#00,#17,#00,#00,#0F,#00,#00       ;........
       DB       #3F,#00,#00,#3F,#00,#00,#3F,#00       ;?..?..?.
       DB       #00,#3F,#00,#00,#3F,#00,#00,#3F       ;.?..?..?
       DB       #00,#00,#3F,#00,#00,#3F,#00,#00       ;..?..?..
       DB       #3F,#00,#0C,#FC,#00,#3F,#FF,#00       ;?..|.?..
       DB       #3F,#F3,#C0,#FF,#C3,#C0,#F7,#CF       ;?s@.C@wO
       DB       #C0,#C3,#83,#C0,#CB,#FF,#C0,#C3       ;@C.@K.@C
       DB       #3F,#F0,#41,#8F,#F0,#41,#03,#F0       ;?pA.pA.p
       DB       #41,#23,#F8,#00,#00,#38,#00,#20       ;A#x..8. 
       DB       #3C,#00,#00,#3C,#00,#20,#F6,#00       ;<..<. v.
       DB       #03,#CA,#00,#4F,#A6,#00,#8F,#56       ;.J.O&..V
       DB       #00,#3E,#2A,#03,#F8,#17,#03,#C0       ;.>*.x..@
       DB       #2F,#00,#00,#3F,#00,#00,#3F,#00       ;/..?..?.
       DB       #00,#3F,#00,#00,#3F,#00,#00,#3F       ;.?..?..?
       DB       #00,#00,#3F,#00,#00,#3F,#00,#00       ;..?..?..
       DB       #3F,#00,#00,#3F,#00,#00,#3F,#00       ;?..?..?.
;
PlayMusic
	LD	HL,L_8539
	LD	(L_844B),HL
	LD	HL,L_876F
	LD	(L_844F),HL
	DI
L_843D	CALL	L_8477
	CALL	L028E
	INC	E
	JR	Z,L_843D
	EI
	RET
;
L_8448       DB       #00
L_8449       DB       #00
L_844A       DB       #00
;
L_844B       DB       #60,#EA,#3A,#85       ;`j:.
L_844F       DB       #48,#EE,#70,#87       ;Hnp.
;
L_8453       DB       #F0
;
L_8454	LD	E,(HL)
	INC	HL
	LD	D,(HL)
	INC	DE
L_8458	LD	A,(DE)
	CP	#40
	JR	Z,L_846F
	LD	(HL),D
	DEC	HL
	LD	(HL),E
	RET
;
L_8461	LD	A,(HL)
	ADD	A,#0C
	LD	E,A
	LD	D,#00
	LD	HL,L_8504
	ADD	HL,DE
	LD	H,(HL)
	LD	L,#01
	RET
;
L_846F	INC	HL
	LD	E,(HL)
	INC	HL
	LD	D,(HL)
	DEC	HL
	DEC	HL
	JR	L_8458
;
L_8477	LD	HL,L_844B
	CALL	L_8454
	LD	(L_8448),A
	LD	HL,L_844F
	CALL	L_8454
	LD	(L_8449),A
	LD	HL,L_8448
	CALL	L_8461
	RL	E
	JP	C,L_853A
	PUSH	HL
	LD	HL,L_8449
	CALL	L_8461
	POP	DE
	LD	A,H
	DEC	A
	JR	NZ,L_84A4
	LD	A,D
	DEC	A
	JR	Z,L_84E6
L_84A4	LD	A,(L_8453)
	LD	C,A
	LD	B,#00
	LD	A,(L_844A)
	EX	AF,AF' ;'
	LD	A,(L_844A)
	LD	XH,D
	LD	D,#10
L_84B5	DB	#00
	DB	#00
L_84B7	EX	AF,AF' ;'
	DEC	E
	OUT	(#FE),A
	JR	NZ,L_84D4
	LD	E,XH
	XOR	D
	EX	AF,AF' ;'
	DEC	L
	JP	NZ,L_84DB
L_84C5	OUT	(#FE),A
	LD	L,H
	XOR	D
	DJNZ	L_84B5
	INC	C
	JP	NZ,L_84B7
	RET
;#84D0
       DB       #61,#64,#61,#6D       ;adam
L_84D4	JR	Z,L_84D4
	EX	AF,AF' ;'
	DEC	L
	JP	Z,L_84C5
L_84DB	OUT	(#FE),A
	DB	#00
	DB	#00
	DJNZ	L_84B5
	INC	C
	JP	NZ,L_84B7
	RET
;
L_84E6	LD	A,(L_8453)
	CPL
	LD	C,A
	PUSH	BC
	PUSH	AF
	LD	B,#00
L_84EF	PUSH	HL
	LD	HL,#0000
	;SRA	(HL)
	;SRA	(HL)
	;SRA	(HL) ;45T
        add hl,hl
        add hl,hl
        add hl,hl
        ds 3 ;45T
	DB	#00
	POP	HL
	DJNZ	L_84EF
	DEC	C
	JP	NZ,L_84EF
	POP	AF
	POP	BC
	RET
;
L_8504       DB       #FF,#F0,#E3,#D7,#CB,#C0,#B4,#AB       ;.pcWK@4+
       DB       #A1,#97,#90,#88,#80,#79,#72,#6C       ;!....yrl
       DB       #66,#60,#5B,#56,#51,#4C,#48,#44       ;f`[VQLHD
       DB       #40,#3D,#39,#36,#33,#30,#2D,#2B       ;@=9630-+
       DB       #28,#26,#24,#22,#20,#1E,#1C,#1B       ;(&$" ...
       DB       #19,#18,#17,#15,#14,#13,#12,#11       ;........
       DB       #10,#0F,#0E,#0D,#0C       ;.....
L_8539       DB       #01       ;.
L_853A       DB       #11,#29,#18,#29,#18,#29,#16,#16       ;.).).)..
       DB       #16,#29,#18,#18,#18,#29,#16,#16       ;.)...)..
       DB       #16,#29,#18,#29,#1B,#29,#1A,#29       ;.).).).)
       DB       #18,#29,#18,#29,#16,#29,#18,#18       ;.).).)..
       DB       #18,#29,#16,#29,#14,#29,#13,#29       ;.).).).)
       DB       #11,#29,#0F,#29,#0C,#0C,#0C,#0C       ;.).)....
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #11,#29,#18,#29,#18,#29,#16,#16       ;.).).)..
       DB       #16,#29,#18,#18,#18,#29,#16,#16       ;.)...)..
       DB       #16,#29,#18,#29,#1B,#29,#1A,#29       ;.).).).)
       DB       #18,#29,#18,#29,#16,#29,#18,#18       ;.).).)..
       DB       #18,#29,#16,#29,#14,#29,#13,#29       ;.).).).)
       DB       #11,#29,#0F,#29,#11,#11,#11,#11       ;.).)....
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #14,#29,#14,#29,#14,#29,#13,#13       ;.).).)..
       DB       #13,#29,#11,#29,#13,#13,#13,#29       ;.).)...)
       DB       #16,#16,#16,#29,#14,#29,#13,#29       ;...).).)
       DB       #11,#29,#18,#29,#16,#29,#13,#29       ;.).).).)
       DB       #14,#29,#14,#29,#14,#29,#13,#13       ;.).).)..
       DB       #13,#29,#11,#29,#13,#13,#13,#29       ;.).)...)
       DB       #16,#16,#16,#29,#14,#29,#16,#29       ;...).).)
       DB       #18,#29,#1D,#29,#1B,#29,#1D,#29       ;.).).).)
       DB       #11,#29,#18,#29,#18,#29,#16,#16       ;.).).)..
       DB       #16,#29,#18,#18,#18,#29,#16,#16       ;.)...)..
       DB       #16,#29,#18,#29,#1B,#29,#1A,#29       ;.).).).)
       DB       #18,#29,#18,#29,#16,#29,#18,#18       ;.).).)..
       DB       #18,#29,#16,#29,#14,#29,#13,#29       ;.).).).)
       DB       #11,#29,#0F,#29,#11,#11,#11,#11       ;.).)....
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#29,#11,#29,#11,#29,#14,#14       ;.).).)..
       DB       #14,#29,#11,#29,#14,#29,#16,#29       ;.).).).)
       DB       #18,#18,#18,#29,#11,#29,#14,#29       ;...).).)
       DB       #19,#29,#18,#29,#14,#29,#18,#29       ;.).).).)
       DB       #1E,#29,#1D,#1D,#1D,#29,#18,#29       ;.)...).)
       DB       #14,#29,#18,#29,#1D,#29,#24,#29       ;.).).)$)
       DB       #22,#29,#24,#29,#20,#29,#20,#29       ;")$) ) )
       DB       #20,#29,#1F,#1F,#1F,#29,#1D,#29       ; )...).)
       DB       #1F,#1F,#1F,#29,#22,#22,#22,#29       ;...)""")
       DB       #20,#29,#1F,#29,#1D,#29,#1B,#29       ; ).).).)
       DB       #18,#29,#18,#29,#18,#29,#16,#16       ;.).).)..
       DB       #16,#29,#14,#29,#16,#29,#16,#29       ;.).).).)
       DB       #1B,#29,#1D,#29,#1F,#29,#22,#29       ;.).).)")
       DB       #20,#29,#20,#29,#20,#29,#1F,#1F       ; ) ) )..
       DB       #1F,#29,#1D,#29,#1F,#1F,#1F,#29       ;.).)...)
       DB       #22,#22,#22,#29,#20,#29,#1F,#29       ;""") ).)
       DB       #1D,#29,#1B,#29,#19,#29,#18,#29       ;.).).).)
       DB       #16,#29,#14,#29,#13,#29,#11,#29       ;.).).).)
       DB       #0F,#29,#0D,#29,#0C,#29,#0C,#0C       ;.).).)..
       DB       #0C,#29,#0C,#29,#0D,#29,#0D,#0D       ;.).).)..
       DB       #0D,#29,#0D,#29,#0A,#29,#0A,#0A       ;.).).)..
       DB       #0A,#29,#0A,#29,#07,#29,#07,#07       ;.).).)..
       DB       #07,#29,#07,#05,#00,#29,#00,#00       ;.)...)..
       DB       #00,#29,#00,#29,#01,#29,#01,#01       ;.).).)..
       DB       #01,#29,#01,#29,#FE,#29,#FE,#FE       ;.).)~)~~
       DB       #FE,#29,#FE,#29,#FB,#29,#FB,#FB       ;~)~){){{
       DB       #FB,#29,#FB,#F9,#F4,#F4,#F4,#F4       ;{){ytttt
       DB       #F4,#F4,#F4,#F4,#F4,#F4,#F4,#F4       ;tttttttt
       DB       #F4,#F4,#F4,#F4,#F4,#F4,#F4,#F4       ;tttttttt
       DB       #F4,#F4,#F4,#F4,#F4,#F4,#FC,#29       ;tttttt|)
       DB       #13,#13,#0F,#0F,#40       ;....@
L_876F       DB       #29,#0C,#29,#11,#29,#11,#29,#0F       ;).).).).
       DB       #0F,#0F,#29,#11,#11,#11,#29,#0F       ;..)...).
       DB       #0F,#0F,#29,#11,#29,#14,#29,#13       ;..).).).
       DB       #29,#11,#29,#11,#29,#0F,#29,#11       ;).).).).
       DB       #11,#11,#29,#0F,#29,#0D,#29,#0C       ;..).).).
       DB       #29,#0A,#29,#08,#29,#F9,#F9,#F9       ;).).)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #F4,#F4,#29,#F9,#F9,#F9,#29,#F4       ;tt)yyy)t
       DB       #29,#F9,#29,#F4,#29,#F9,#F9,#F9       ;)y)t)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #29,#F9,#29,#F4,#29,#F7,#29,#F4       ;)y)t)w)t
       DB       #29,#0C,#29,#11,#29,#11,#29,#0F       ;).).).).
       DB       #0F,#0F,#29,#11,#11,#11,#29,#0F       ;..)...).
       DB       #0F,#0F,#29,#11,#29,#14,#29,#13       ;..).).).
       DB       #29,#11,#29,#11,#29,#0F,#29,#11       ;).).).).
       DB       #11,#11,#29,#0F,#29,#0D,#29,#0C       ;..).).).
       DB       #29,#0A,#29,#08,#29,#F9,#F9,#F9       ;).).)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #F4,#F4,#29,#F9,#F9,#F9,#29,#F4       ;tt)yyy)t
       DB       #29,#F9,#29,#F4,#29,#F9,#F9,#F9       ;)y)t)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #29,#01,#29,#01,#29,#01,#29,#03       ;).).).).
       DB       #03,#03,#29,#FE,#29,#03,#03,#03       ;..)~)...
       DB       #29,#07,#07,#07,#29,#05,#29,#03       ;)...).).
       DB       #29,#FE,#29,#08,#29,#07,#29,#03       ;)~).).).
       DB       #29,#05,#29,#05,#29,#05,#29,#03       ;).).).).
       DB       #03,#03,#29,#FE,#29,#03,#03,#03       ;..)~)...
       DB       #29,#07,#07,#07,#29,#05,#29,#07       ;)...).).
       DB       #29,#08,#29,#0C,#29,#0A,#29,#0C       ;).).).).
       DB       #29,#00,#29,#05,#29,#05,#29,#03       ;).).).).
       DB       #03,#03,#29,#05,#05,#05,#29,#03       ;..)...).
       DB       #03,#03,#29,#05,#29,#08,#29,#07       ;..).).).
       DB       #29,#05,#29,#05,#29,#03,#29,#05       ;).).).).
       DB       #05,#05,#29,#03,#29,#01,#29,#00       ;..).).).
       DB       #29,#FE,#29,#FC,#29,#F9,#F9,#F9       ;)~)|)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #F4,#F4,#29,#F9,#F9,#F9,#29,#F4       ;tt)yyy)t
       DB       #29,#F9,#29,#F4,#29,#F9,#F9,#F9       ;)y)t)yyy
       DB       #29,#F4,#29,#F9,#F9,#F9,#29,#F4       ;)t)yyy)t
       DB       #29,#F9,#29,#F4,#29,#F7,#29,#F4       ;)y)t)w)t
       DB       #29,#F9,#29,#F9,#29,#F9,#29,#FC       ;)y)y)y)|
       DB       #FC,#FC,#29,#F9,#29,#FC,#29,#FE       ;||)y)|)~
       DB       #29,#00,#00,#00,#29,#05,#29,#08       ;)...).).
       DB       #29,#0D,#29,#0C,#29,#08,#29,#0C       ;).).).).
       DB       #29,#12,#29,#11,#11,#11,#29,#0C       ;).)...).
       DB       #29,#08,#29,#0C,#29,#11,#11,#11       ;).).)...
       DB       #29,#0F,#0F,#0F,#29,#0D,#29,#0D       ;)...).).
       DB       #29,#0D,#29,#0F,#0F,#0F,#29,#0A       ;).)...).
       DB       #29,#0F,#0F,#0F,#29,#13,#13,#13       ;)...)...
       DB       #29,#11,#29,#0F,#29,#0C,#29,#0A       ;).).).).
       DB       #29,#08,#29,#08,#29,#08,#29,#07       ;).).).).
       DB       #07,#07,#29,#05,#29,#07,#29,#07       ;..).).).
       DB       #29,#0A,#29,#0C,#29,#0F,#29,#13       ;).).).).
       DB       #29,#11,#29,#11,#29,#11,#29,#0F       ;).).).).
       DB       #0F,#0F,#29,#0A,#29,#0F,#0F,#0F       ;..).)...
       DB       #29,#13,#13,#13,#29,#11,#29,#0F       ;)...).).
       DB       #29,#0D,#29,#0C,#29,#0A,#29,#08       ;).).).).
       DB       #29,#07,#29,#05,#29,#03,#29,#01       ;).).).).
       DB       #29,#00,#29,#FE,#29,#0C,#0C,#0C       ;).)~)...
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#29,#0C,#0A,#0C,#0C,#0C       ;..).....
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#29,#0C,#0A,#0C,#0C,#0C       ;..).....
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#0C       ;........
       DB       #0C,#0C,#0C,#0C,#0C,#0C,#0C,#14       ;........
       DB       #29,#FB,#FB,#F7,#F7,#40,#00,#00       ;){{ww@..
       DB       #00       ;.
;
;#89A8
;	org #89a8
;STARD
GO
	DI
	LD	SP,#0000
	CALL	Init
L_89AF	DI
	LD	SP,#0000
	LD	A,#FF
	LD	(L_B9C6),A
	CALL	PrintMenu
	LD	HL,#0000
	PUSH	HL
	LD	(L_B945),HL
	LD	(L_B947),HL
	CALL	L_8A62
	CALL	L_8A6B
	LD	HL,L_40AF
	POP	DE
	LD	B,#02
	LD	IX,L_B9A4
	CALL	L_8CE3
	CALL	L_8A56
L_89DB	XOR	A
	LD	(L_B972),A
	LD	(L_B6DA),A
	LD	(L_B56B),A
	CALL	CopyScreenHgt94
	CALL	L_97C1
	CALL	L_8FA8
	CALL	L_8FB9
L_89F1	CALL	CopyScreenHgt94
	CALL	L_9AC1
	CALL	L_946D
	CALL	L_995A
	CALL	L_9C20
	EI
	HALT
	DI
	CALL	CopyScreenHgt89
	CALL	L_8A7A
	CALL	L_9C9C
	CALL	L_9A2C
	CALL	L_8ACB
	CALL	L_8A62
	CALL	L_8A6B
	CALL	L_8D09
	LD	A,(L_B94F)
	CALL	DecodeKey
	JR	NC,L_8A35
	LD	A,(L_B94E)
	CALL	DecodeKey
	JP	NC,L_8ABA
	LD	A,(L_B6D8)
	OR	A
	JP	Z,L_8A9F
	JR	L_89F1
;
L_8A35	LD	A,#10
	LD	(L_B560),A
	LD	(L_B569),A
	CALL	L_995A
	XOR	A
	LD	(L_B9D8),A
	LD	(L_B576),A
	LD	HL,L_6880
	LD	(L_B57B),HL
	LD	HL,L_B616
	LD	(L_B57D),HL
	JP	L_89AF
;
L_8A56	LD	A,(L_B6D8)
	CP	#FF
	RET	Z
	LD	A,#65
	LD	(L_B6D8),A
	RET
;
L_8A62	LD	HL,L_40A9
	LD	DE,(L_B945)
	JR	L_8A72
;
L_8A6B	LD	HL,L_40B2
	LD	DE,(L_B947)
L_8A72	PUSH	AF
	LD	B,#05
	CALL	PrintNumDE
	POP	AF
	RET
;
L_8A7A	LD	HL,(RedAttrAddr)
	LD	A,(HL)
	AND	#F8
	LD	(HL),A
	RET
;
L_8A82	LD	A,(L_B576)
	XOR	#01
	LD	(L_B576),A
	PUSH	AF
	LD	HL,L_B577
	CALL	GetHLfromHLplus2A
	POP	AF
	LD	(L_B57B),HL
	LD	HL,L_B57F
	CALL	GetHLfromHLplus2A
	LD	(L_B57D),HL
	RET
;
L_8A9F	LD	A,(L_B9C6)
	INC	A
	CP	#08
	CALL	NZ,L_8A82
	LD	A,(L_B6D8)
	OR	A
	JR	NZ,L_8AB7
	XOR	A
	LD	(L_B9C6),A
	LD	A,#5A
	LD	(L_B6D8),A
L_8AB7	JP	L_89DB
;
L_8ABA	CALL	L_9C08
	CALL	Pause6060
L_8AC0	LD	A,(L_B94E)
	CALL	DecodeKey
	JR	C,L_8AC0
	JP	L_89F1
;
L_8ACB	LD	A,(L_B6D3)
	OR	A
	RET	Z
	PUSH	AF
	CP	#05
	JP	Z,L_8B5D
	CP	#06
	JP	Z,L_8B5D
	LD	IY,(L_B6D4)
	LD	A,(IY+#08)
	LD	HL,L_B69B
	CALL	L_95B5
	JR	NZ,L_8B3C
	PUSH	DE
	LD	E,(IY+#03)
	LD	D,#00
	LD	HL,L_5940
	ADD	HL,DE
	POP	DE
	LD	A,D
	OR	A
	JR	Z,L_8B00
	LD	BC,#0020
L_8AFC	ADD	HL,BC
	DEC	A
	JR	NZ,L_8AFC
L_8B00	BIT	0,(IY+#02)
	JR	Z,L_8B0F
	LD	C,#08
	ADD	HL,BC
	LD	C,E
	AND	A
	SBC	HL,BC
	JR	L_8B11
;
L_8B0F	LD	C,E
	ADD	HL,BC
L_8B11	LD	B,L
	LD	A,L
	AND	#1F
	OR	A
	JR	Z,L_8B3C
	CP	#01
	JR	Z,L_8B3C
	CP	#1F
	JR	Z,L_8B3C
	CP	#1E
	JR	Z,L_8B3C
	LD	L,B
	LD	A,(HL)
	AND	#F8
	OR	#02
	LD	(HL),A
	LD	(RedAttrAddr),HL
	LD	A,H
	AND	#03
	RLCA
	RLCA
	RLCA
	OR	#40
	LD	H,A
	LD	A,#3D
	CALL	PrintChar88
L_8B3C	LD	A,(IY+#08)
	LD	HL,L_B6B7
	CALL	L_95B5
	JR	NZ,L_8B5D
	LD	A,YL
	CP	#59
	JR	Z,L_8B56
	LD	HL,(L_B947)
	ADD	HL,DE
	LD	(L_B947),HL
	JR	L_8B5D
;
L_8B56	LD	HL,(L_B945)
	ADD	HL,DE
	LD	(L_B945),HL
L_8B5D	XOR	A
	LD	(L_B6D3),A
	POP	AF
        display $
	CP	#01
	JP	Z,L_9BFC
	CP	#02
	JP	Z,L_9BF6
	CP	#03
	JP	Z,L_9C02
	CP	#04
	JP	Z,L_9C08
	CP	#05
	JP	Z,L_9C0E
	CP	#06
	JP	Z,L_9C14
	RET
;
L_8B81	LD	A,(IY+#00)
	BIT	7,A
	JR	NZ,L_8B91
	OR	A
	RET	Z
	CALL	L_8BF1
	LD	(IY+#01),A
	RET
;
L_8B91	LD	A,YL
	CP	#59
	JR	NZ,L_8BA6
	LD	A,(L_B56A)
	PUSH	IY
	LD	IY,L_B559
	CALL	L_8BB5
	POP	IY
	RET
;
L_8BA6	LD	A,(L_B561)
	PUSH	IY
	LD	IY,L_B562
	CALL	L_8BB5
	POP	IY
	RET
;
L_8BB5	LD	HL,L_BA02
	CALL	GetHLfromHLplus2A
	PUSH	HL
	LD	A,(L_B6F2)
	LD	HL,L_B9DA
	CALL	GetMHLfromHLplusA
	POP	HL
	CALL	GetMHLfromHLplusA
	LD	DE,#0008
	CALL	L_8C88
	LD	DE,L_BB66
	ADD	HL,DE
	PUSH	HL
	LD	A,R
	AND	#1F
	PUSH	AF
	LD	A,(L_B9C6)
	LD	HL,L_B9C7
	CALL	GetHLfromHLplus2A
	POP	AF
	CALL	GetMHLfromHLplusA
	POP	HL
	CALL	GetMHLfromHLplusA
	CALL	L_98E6
	LD	(IY+#01),A
	RET
;
L_8BF1	LD	HL,L_B949
	CP	#01
	JR	Z,L_8C15
	LD	HL,L_B950
	CP	#02
	JR	Z,L_8C15
	LD	HL,L_B955
	CP	#03
	JR	Z,L_8C15
	LD	HL,L_B95A
	CP	#04
	JR	Z,L_8C15
	CP	#05
	RET	NZ
curkempston=$+1
       ld a,0
	;IN	A,(#1F)
	AND	#1F
	RET
;
L_8C15	LD	E,#00
	LD	D,#05
L_8C19	LD	A,(HL)
	INC	HL
	CALL	DecodeKey
	CCF
	RL	E
	DEC	D
	JR	NZ,L_8C19
	LD	A,E
	RET
;
ReadKeyMatrix
	LD	DE,L_FF2F
	LD	BC,L_FEFE
L_8C2C	IN	A,(C)
	CPL
	AND	#1F
	JR	Z,L_8C3F
	INC	D
	RET	NZ
	LD	H,A
	LD	A,E
L_8C37	SUB	#08
	SRL	H
	JR	NC,L_8C37
	RET	NZ
	LD	D,A
L_8C3F	DEC	E
	RLC	B
	JR	C,L_8C2C
	CP	A
	RET	Z
DecodeKey
	LD	C,A
	AND	#07
	INC	A
	LD	B,A
	SRL	C
	SRL	C
	SRL	C
	LD	A,#05
	SUB	C
	LD	C,A
	LD	A,#FE
L_8C57	RRCA
	DJNZ	L_8C57
	IN	A,(#FE)
L_8C5C	RRA
	DEC	C
	JR	NZ,L_8C5C
	RET
;
L_8C61	PUSH	HL
	LD	A,#3F
	CALL	PrintChar88
	CALL	Pause6060
	CALL	ReadKeyMatrix
	POP	HL
	LD	A,D
	CP	#FF
	JR	Z,L_8C61
	PUSH	AF
	PUSH	HL
	LD	HL,L_B974
	CALL	GetMHLfromHLplusA
	POP	HL
	CALL	PrintChar88
	PUSH	IX
	CALL	L_9C08
	POP	IX
	POP	AF
	RET
;
L_8C88	LD	HL,#0000
	OR	A
	RET	Z
	LD	B,#08
L_8C8F	SRL	A
	JP	NC,L_8C95
	ADD	HL,DE
L_8C95	SLA	E
	RL	D
	DJNZ	L_8C8F
	RET
;
PrintChar88
	PUSH	HL
	SUB	#30
	LD	L,A
	LD	H,#00
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	LD	DE,font88
	ADD	HL,DE
	POP	DE
	EX	DE,HL
	LD	B,#08
L_8CAD	LD	A,(DE)
	LD	(HL),A
	CALL	DownHL
	INC	DE
	DJNZ	L_8CAD
	RET
;
PrintString88
	LD	A,(DE)
L_8CB7	PUSH	DE
	PUSH	HL
	CALL	PrintChar88
	POP	HL
	POP	DE
	INC	L
	INC	DE
	LD	A,(DE)
	OR	A
	JR	NZ,L_8CB7
	RET
;
PrintStrings88
	PUSH	DE
	LD	A,(DE)
	CALL	L_8CD5
	CALL	PrintString88
	POP	DE
	INC	DE
	LD	A,(DE)
	CP	#FF
	JR	NZ,PrintStrings88
	RET
;
L_8CD5	PUSH	HL
	LD	HL,L_BE61
	CALL	GetHLfromHLplus2A
	POP	DE
	EX	DE,HL
	RET
;
PrintNumDE
	LD	IX,L_B99E
L_8CE3	PUSH	BC
	PUSH	DE
	EXX
	POP	HL
	POP	BC
L_8CE8	LD	E,(IX+#00)
	LD	D,(IX+#01)
	LD	C,#FF
	AND	A
L_8CF1	SBC	HL,DE
	INC	C
	JR	NC,L_8CF1
	ADD	HL,DE
	LD	A,C
	ADD	A,#30
	EXX
	PUSH	HL
	CALL	PrintChar88
	POP	HL
	INC	HL
	EXX
	INC	IX
	INC	IX
	DJNZ	L_8CE8
	RET
;
L_8D09	LD	A,(L_B6D8)
	CP	#FF
	JR	NZ,L_8D13
	LD	A,(L_B9C6)
L_8D13	LD	HL,L_40AF
	LD	E,A
	LD	D,#00
	LD	B,#02
	LD	IX,L_B9A4
	JP	L_8CE3
;
PrintMenu
	CALL	L_972B
L_8D25	LD	HL,L_4845
	LD	DE,L_BE9B
	CALL	PrintStrings88
	LD	HL,L_4886
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48A6
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48C6
	INC	DE
	CALL	PrintStrings88
	CALL	L_8F62
L_8D46	CALL	PlayMusic_CheckQuit
	LD	A,#23
	CALL	DecodeKey
	JP	NC,GoKeyDemo
	LD	A,#24
	CALL	DecodeKey
	JR	NC,L_8D74
	LD	A,#1C
	CALL	DecodeKey
	JP	NC,L_8E9C
	LD	A,#14
	CALL	DecodeKey
	JR	C,L_8D46
	LD	HL,L_4845
	PUSH	DE
	LD	DE,L_BE16
	CALL	PrintString88
	POP	DE
	JR	L_8D46
;
L_8D74	LD	A,#19
	LD	(L_BE9F),A
	XOR	A
	LD	(L_99CB),A
	LD	A,#FF
	LD	(L_B6D8),A
	LD	A,(L_B559)
	AND	#7F
	LD	(L_B559),A
	LD	A,(L_B562)
	OR	#80
	LD	(L_B562),A
	CALL	GoKeyDemo
	LD	HL,L_4886
	LD	DE,L_BEA9
	CALL	PrintStrings88
	LD	HL,L_48A6
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48C6
	INC	DE
	CALL	PrintStrings88
	CALL	L_8F62
L_8DAF	LD	A,#24
	CALL	DecodeKey
	JR	NC,L_8DC6
	LD	A,#1C
	CALL	DecodeKey
	JR	NC,L_8DD1
	LD	A,#14
	CALL	DecodeKey
	JR	NC,L_8DDC
	JR	L_8DAF
;
L_8DC6	LD	A,#03
	LD	(L_B559),A
	CALL	GoKeyDemo
	JP	L_8D25
;
L_8DD1	LD	A,#05
	LD	(L_B559),A
	CALL	GoKeyDemo
	JP	L_8D25
;
L_8DDC	XOR	A
	LD	(L_B94F),A
	LD	(L_B94E),A
	LD	IX,L_B949
	LD	A,#01
	LD	(L_B559),A
	LD	A,(L_B562)
	SET	7,A
	LD	(L_B562),A
	LD	A,#01
	LD	(L_BEB8),A
	JR	L_8E0B
;
L_8DFB	LD	IX,L_B950
	LD	A,#02
	LD	(L_B562),A
	LD	A,#02
	LD	(L_BEB8),A
	JR	L_8E0B
;
L_8E0B	CALL	GoKeyDemo
	LD	HL,L_4845
	LD	DE,L_BEB4
	CALL	PrintStrings88
	LD	HL,L_4886
	INC	DE
	LD	B,#04
L_8E1D	PUSH	BC
	PUSH	HL
	CALL	PrintStrings88
	POP	HL
	LD	BC,#0020
	ADD	HL,BC
	INC	DE
	POP	BC
	DJNZ	L_8E1D
	LD	HL,L_5006
	CALL	PrintStrings88
	LD	HL,L_5026
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_5046
	INC	DE
	CALL	PrintStrings88
	CALL	L_8F62
	LD	HL,L_4896
	LD	B,#04
L_8E47	PUSH	BC
	PUSH	HL
	CALL	L_8C61
	LD	(IX+#00),A
	INC	IX
	POP	HL
	CALL	Pause6060
	CALL	Pause6060
	LD	BC,#0020
	ADD	HL,BC
	POP	BC
	DJNZ	L_8E47
	LD	HL,L_5016
	CALL	L_8C61
	LD	(IX+#00),A
	CALL	Pause6060
	CALL	Pause6060
	LD	A,(L_B94E)
	OR	A
	LD	HL,L_5036
	CALL	Z,L_8C61
	LD	(L_B94E),A
	CALL	Pause6060
	CALL	Pause6060
	LD	A,(L_B94F)
	OR	A
	LD	HL,L_5056
	CALL	Z,L_8C61
	LD	(L_B94F),A
	LD	A,#0E
L_8E90	CALL	Pause6060
	DEC	A
	JR	NZ,L_8E90
L_8E96	CALL	GoKeyDemo
	JP	L_8D25
;
L_8E9C	LD	A,#19
	LD	(L_BE9F),A
	XOR	A
	LD	(L_99CB),A
	LD	A,#5A
	LD	(L_B6D8),A
	LD	A,(L_B559)
	AND	#7F
	LD	(L_B559),A
	LD	A,(L_B562)
	AND	#7F
	LD	(L_B562),A
	CALL	GoKeyDemo
	LD	HL,L_4845
	LD	DE,L_BED6
	CALL	PrintStrings88
	LD	HL,L_4886
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48A6
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48C6
	INC	DE
	CALL	PrintStrings88
	LD	HL,L_48E6
	INC	DE
	CALL	PrintStrings88
	CALL	L_8F62
L_8EE5	LD	A,#24
	CALL	DecodeKey
	JR	NC,L_8F04
	LD	A,#1C
	CALL	DecodeKey
	JP	NC,L_8F13
	LD	A,#14
	CALL	DecodeKey
	JR	NC,L_8F22
	LD	A,#0C
	CALL	DecodeKey
	JR	NC,L_8F31
	JR	L_8EE5
;
L_8F04	CALL	GoKeyDemo
	LD	A,#03
	LD	(L_B559),A
	INC	A
	LD	(L_B562),A
	JP	L_8D25
;
L_8F13	LD	A,#03
	LD	(L_B559),A
	XOR	A
	LD	(L_B94F),A
	LD	(L_B94E),A
	JP	L_8DFB
;
L_8F22	LD	A,#05
	LD	(L_B559),A
	XOR	A
	LD	(L_B94F),A
	LD	(L_B94E),A
	JP	L_8DFB
;
L_8F31	LD	A,#C9
	LD	(L_8E96),A
	CALL	L_8DDC
	LD	A,#CD
	LD	(L_8E96),A
	JP	L_8DFB
;
GoKeyDemo
	LD	B,#07
L_8F43	PUSH	BC
	LD	HL,L_58E2
	INC	HL
	LD	BC,#1A0F
	CALL	FadeOutHL_BCwh
	CALL	Pause6060
	POP	BC
	DJNZ	L_8F43
	LD	A,#C9
	LD	(Pause6060),A
	CALL	L_972B
	LD	A,#01
	LD	(Pause6060),A
	RET
;
L_8F62	LD	B,#07
L_8F64	PUSH	BC
	CALL	Pause6060
	LD	A,#07
	LD	HL,L_5945
	LD	BC,#1501
	CALL	FadeInHL_BCwh
	DEC	A
	LD	HL,L_5986
	CALL	FadeInHL_BCwh
	ADD	HL,DE
	DEC	A
	CALL	FadeInHL_BCwh
	ADD	HL,DE
	DEC	A
	CALL	FadeInHL_BCwh
	ADD	HL,DE
	DEC	A
	CALL	FadeInHL_BCwh
	ADD	HL,DE
	INC	A
	CALL	FadeInHL_BCwh
	ADD	HL,DE
	INC	A
	LD	E,A
	LD	A,(L_B94F)
	OR	A
	LD	A,E
	CALL	Z,FadeInHL_BCwh
	ADD	HL,DE
	INC	A
	LD	E,A
	LD	A,(L_B94E)
	OR	A
	LD	A,E
	CALL	Z,FadeInHL_BCwh
	POP	BC
	DJNZ	L_8F64
	RET
;
L_8FA8	LD	IY,L_B559
	XOR	A
	CALL	L_8FD6
	LD	A,(L_B55B)
	RES	0,A
	LD	(L_B55B),A
	RET
;
L_8FB9	LD	A,(L_B9C6)
	INC	A
	CP	#08
	JR	Z,L_8FC4
	LD	(L_B9C6),A
L_8FC4	LD	IY,L_B562
	LD	A,#17
	CALL	L_8FD6
	LD	A,(L_B564)
	SET	0,A
	LD	(L_B564),A
	RET
;
L_8FD6	LD	(IY+#03),A
	LD	A,#1C
	CALL	L_8FE6
	LD	A,#0D
	LD	(IY+#07),A
	JP	L_99C7
;
L_8FE6	LD	B,(IY+#06)
	CP	B
	RET	Z
L_8FEB	PUSH	HL
	PUSH	AF
	CALL	GetMHLfromL_AED3plusA
	LD	B,(IY+#02)
	AND	#80
	OR	B
	LD	(IY+#02),A
	POP	AF
	LD	(IY+#06),A
	LD	HL,L_AD85
	CALL	GetHLfromHLplus2A
	LD	(IY+#04),L
	LD	(IY+#05),H
	LD	A,(HL)
	LD	(IY+#08),A
	POP	HL
	RET
;
UpHL	DEC	H
	LD	A,H
	CPL
	AND	#07
	RET	NZ
	LD	A,L
	SUB	#20
	LD	L,A
	RET	C
	LD	A,H
	ADD	A,#08
	LD	H,A
	RET
;
DownHL	INC	H
	LD	A,H
	AND	#07
	RET	NZ
	LD	A,L
	ADD	A,#20
	LD	L,A
	RET	C
	LD	A,H
	SUB	#08
	LD	H,A
	RET
;
L_902E	LD	A,(DE)
	INC	E
	BIT	7,A
	JP	NZ,L_9162
	LD	C,A
	AND	#03
	CP	#03
	JP	Z,L_9127
	OR	A
	JP	Z,ReLinear24x21
	LD	A,C
	BIT	6,A
	JR	Z,L_9048
	XOR	#03
L_9048	BIT	0,A
	JP	NZ,L_9084
	LD	B,#15
L_904F	CALL	L_9055
	DJNZ	L_904F
	RET
;
L_9055	LD	C,#FF
	LD	A,(DE)
	CP	C
	JR	Z,L_9060
	CALL	L_90C1
	JR	L_9074
;
L_9060	INC	E
	INC	L
	LD	A,(DE)
	CP	C
	JR	Z,L_906B
	CALL	L_90C1
	JR	L_9078
;
L_906B	INC	E
	INC	L
	LD	A,(DE)
	CP	C
	CALL	NZ,L_90C1
	JR	L_907C
;
L_9074	INC	E
	INC	L
	LD	A,(DE)
	LD	(HL),A
L_9078	INC	E
	INC	L
	LD	A,(DE)
	LD	(HL),A
L_907C	PUSH	DE
	LD	DE,#001E
	ADD	HL,DE
	POP	DE
	INC	E
	RET
;
L_9084	LD	B,#15
L_9086	CALL	L_908C
	DJNZ	L_9086
	RET
;
L_908C	LD	C,#FF
	INC	L
	INC	L
	INC	E
	INC	E
	LD	A,(DE)
	CP	C
	JR	Z,L_909B
	CALL	L_90FA
	JR	L_90AF
;
L_909B	DEC	E
	DEC	L
	LD	A,(DE)
	CP	C
	JR	Z,L_90A6
	CALL	L_90FA
	JR	L_90B3
;
L_90A6	DEC	E
	DEC	L
	LD	A,(DE)
	CP	C
	CALL	NZ,L_90FA
	JR	L_90B7
;
L_90AF	DEC	E
	DEC	L
	LD	A,(DE)
	LD	(HL),A
L_90B3	DEC	E
	DEC	L
	LD	A,(DE)
	LD	(HL),A
L_90B7	PUSH	DE
	LD	DE,#0020
	ADD	HL,DE
	POP	DE
	INC	E
	INC	E
	INC	E
	RET
;
L_90C1	LD	C,A
	BIT	7,C
	JR	Z,L_90F7
	LD	A,#80
	BIT	6,C
	JR	Z,L_90EC
	LD	A,#C0
	BIT	5,C
	JR	Z,L_90EC
	LD	A,#E0
	BIT	4,C
	JR	Z,L_90EC
	LD	A,#F0
	BIT	3,C
	JR	Z,L_90EC
	LD	A,#F8
	BIT	2,C
	JR	Z,L_90EC
	LD	A,#FC
	BIT	1,C
	JR	Z,L_90EC
	LD	A,#FE
L_90EC	LD	C,A
	LD	A,(HL)
	AND	C
	LD	(HL),A
	LD	A,(DE)
	XOR	C
	LD	C,A
	LD	A,(HL)
	OR	C
	LD	(HL),A
	RET
;
L_90F7	LD	A,C
	LD	(HL),A
	RET
;
L_90FA	LD	C,A
	BIT	0,C
	JR	Z,L_90F7
	LD	A,#01
	BIT	1,C
	JR	Z,L_90EC
	LD	A,#03
	BIT	2,C
	JR	Z,L_90EC
	LD	A,#07
	BIT	3,C
	JR	Z,L_90EC
	LD	A,#0F
	BIT	4,C
	JR	Z,L_90EC
	LD	A,#1F
	BIT	5,C
	JR	Z,L_90EC
	LD	A,#3F
	BIT	6,C
	JR	Z,L_90EC
	LD	A,#7F
	JR	L_90EC
;
L_9127	LD	B,#15
L_9129	PUSH	BC
	PUSH	HL
	PUSH	DE
	EXX
	POP	DE
	POP	HL
	PUSH	HL
	LD	A,(HL)
	LD	(L_B95F),A
	INC	L
	LD	A,(HL)
	LD	(L_B960),A
	INC	L
	LD	A,(HL)
	LD	(L_B961),A
	DEC	L
	DEC	L
	EXX
	LD	HL,L_B95F
	CALL	L_9055
	EXX
	CALL	L_908C
	EXX
	LD	HL,L_B95F
	POP	DE
	LD	A,(DE)
	AND	(HL)
	LD	(DE),A
	INC	HL
	INC	E
	LD	A,(DE)
	AND	(HL)
	LD	(DE),A
	INC	HL
	INC	E
	LD	A,(DE)
	AND	(HL)
	LD	(DE),A
	EXX
	POP	BC
	DJNZ	L_9129
	RET
;
L_9162	LD	C,A
	EX	AF,AF' ;'
	LD	A,C
	AND	#3F
	CALL	L_91C5
	LD	A,(BC)
L_916B	AND	#C0
	CP	#C0
	JR	Z,L_9190
	CP	#00
	JR	Z,L_91A0
	EX	AF,AF' ;'
	BIT	6,A
	JR	Z,L_9186
	EX	AF,AF' ;'
	LD	A,(BC)
	XOR	#C0
	CALL	L_91B0
	BIT	5,A
	JR	Z,L_916B
	RET
;
L_9186	EX	AF,AF' ;'
	LD	A,(BC)
	CALL	L_91B0
	BIT	5,A
	JR	Z,L_916B
	RET
;
L_9190	LD	A,(BC)
	PUSH	BC
	AND	#1F
	LD	B,A
	CALL	L_9129
	POP	BC
	INC	BC
	LD	A,(BC)
	BIT	5,A
	JR	Z,L_916B
	RET
;
L_91A0	LD	A,(BC)
	PUSH	BC
	AND	#1F
	LD	B,A
	CALL	L_91D5
	POP	BC
	INC	BC
	LD	A,(BC)
	BIT	5,A
	JR	Z,L_916B
	RET
;
L_91B0	PUSH	BC
	LD	C,A
	AND	#1F
	LD	B,A
	BIT	6,C
	JR	NZ,L_91BE
	CALL	L_904F
	JR	L_91C1
;
L_91BE	CALL	L_9086
L_91C1	POP	BC
	INC	BC
	LD	A,(BC)
	RET
;
L_91C5	PUSH	HL
	ADD	A,A
	LD	C,A
	LD	B,#00
	LD	HL,L_BD31
	ADD	HL,BC
	LD	C,(HL)
	INC	HL
	LD	B,(HL)
	POP	HL
	RET
;
ReLinear24x21
	LD	B,#15
L_91D5	PUSH	HL
	LD	A,(DE)
	LD	(HL),A
	INC	E
	INC	L
	LD	A,(DE)
	LD	(HL),A
	INC	E
	INC	L
	LD	A,(DE)
	LD	(HL),A
	INC	E
	POP	HL
	PUSH	DE
	LD	DE,#0020
	ADD	HL,DE
	POP	DE
	DJNZ	L_91D5
	RET
;
L_91EB	LD	D,A
	LD	A,YL
	CP	#6B
	LD	A,D
	JR	NZ,L_91F8
	LD	DE,L_9D00
	JR	L_91FB
;
L_91F8	LD	DE,L_C000
L_91F9       EQU       $-2
L_91FB	PUSH	HL
	LD	H,A
	LD	L,#00
	SRL	H
	RR	L
	SRL	H
	RR	L
	ADD	HL,DE
	EX	DE,HL
	POP	HL
	RET
;
DrawImg_HLscr_BCwh
	PUSH	BC
	PUSH	HL
L_920D	LD	A,(DE)
	LD	(HL),A
	INC	HL
	INC	DE
	DJNZ	L_920D
	POP	HL
	CALL	DownHL
	POP	BC
	DEC	C
	JR	NZ,DrawImg_HLscr_BCwh
	RET
;
L_921C	LD	B,#04
	LD	A,(DE)
	LD	C,A
	INC	DE
	PUSH	DE
	POP	IX
L_9224	LD	A,(IY+#02)
	BIT	0,A
	JR	Z,L_922D
	INC	C
	INC	C
L_922D	CALL	L_9249
	CALL	L_9249
	CALL	L_9249
	LD	DE,#0297
	ADD	HL,DE
	DEC	B
	RET	Z
	LD	A,(IY+#02)
	BIT	0,A
	JR	Z,L_9224
	INC	C
	INC	C
	INC	C
	INC	C
	JR	L_9224
;
L_9249	PUSH	BC
	LD	B,#AA
	LD	A,(BC)
	INC	A
	JR	Z,L_925F
	DEC	A
	LD	(L_9256),A
	LD	A,(IX+#00)
L_9256       EQU       $-1
	PUSH	HL
	CALL	L_91EB
	CALL	L_902E
	POP	HL
L_925F	POP	BC
	INC	L
	INC	L
	INC	L
	LD	A,(IY+#02)
	BIT	0,A
	JR	Z,L_926C
	DEC	C
	RET
L_926C	INC	C
	RET
;
L_926E	PUSH	AF
	LD	A,(IY+#00)
	OR	A
	JR	Z,L_929E
	LD	E,(IY+#04)
	LD	D,(IY+#05)
	LD	A,(DE)
	CP	#11
	CALL	Z,L_93EA
	LD	(IY+#08),A
	LD	HL,L_AC9D
	CALL	GetHLfromHLplus2A
	PUSH	HL
	LD	A,(HL)
	LD	XL,A
	LD	XH,#AA
	INC	HL
	CALL	L_95DF
	POP	DE
	LD	L,(IY+#03)
	LD	H,#5E
	CALL	L_921C
L_929E	POP	AF
	RET
;
L_92A0	LD	E,(IY+#04)
	LD	D,(IY+#05)
	LD	A,(DE)
	CP	#14
	CALL	Z,L_9322
	INC	DE
	LD	(IY+#04),E
	LD	(IY+#05),D
	LD	A,(DE)
	LD	(IY+#08),A
	CP	#21
	PUSH	AF
	CALL	Z,L_9322
	POP	AF
	INC	DE
	PUSH	AF
	CP	#57
	PUSH	DE
	PUSH	AF
	CALL	Z,L_9BF6
	POP	AF
	POP	DE
	LD	A,(DE)
	CP	#FD
	JR	C,L_92D1
	CALL	L_92F6
L_92D1	DEC	DE
	POP	AF
	CP	#FD
	RET	C
	CP	#FD
	JR	Z,L_92EB
	CP	#FF
	JR	Z,L_92FB
	DEC	DE
	LD	(IY+#04),E
	LD	(IY+#05),D
	LD	A,(DE)
	LD	(IY+#08),A
	JR	L_92F6
;
L_92EB	LD	A,(IY+#06)
	CALL	L_8FEB
	JR	L_92F6
;
L_92F3	CALL	L_8FE6
L_92F6	RES	7,(IY+#02)
	RET
;
L_92FB	INC	DE
	LD	A,(DE)
	JR	L_92F3
;
L_92FF	LD	IY,L_B559
	LD	A,(IY+#06)
	CP	#13
	JR	NZ,L_9310
	CALL	L_9352
	JP	L_8FB9
;
L_9310	LD	A,(L_B6D8)
	CP	#FF
	JP	Z,L_8A35
	LD	IY,L_B562
	CALL	L_9374
	JP	L_8FA8
;
L_9322	LD	A,(L_B56B)
	CP	#FF
	RET	Z
	LD	A,(L_B6DA)
	CP	#FF
	JR	Z,L_9331
	OR	A
	RET	NZ
L_9331	PUSH	IY
	LD	A,#1E
	CALL	L_9345
	XOR	A
	LD	(L_B56E),A
	LD	(L_B56D),A
	LD	(L_B9D8),A
	POP	IY
	RET
;
L_9345	LD	IY,L_B56B
	CALL	L_8FE6
	LD	A,#FF
	LD	(L_B56B),A
	RET
;
L_9352	CALL	L_939F
	CALL	L_938C
	RET	NZ
	XOR	#01
	LD	(L_B55B),A
	LD	A,(L_B55C)
	ADD	A,#04
	CP	#18
	RET	NC
	CP	#18
	JR	Z,L_936E
	LD	(L_B55C),A
	RET
;
L_936E	LD	A,#17
	LD	(L_B55C),A
	RET
;
L_9374	CALL	L_93BB
	CALL	L_938C
	RET	NZ
	XOR	#01
	LD	(L_B564),A
	LD	A,(L_B565)
	SUB	#04
	CP	#18
	RET	NC
	LD	(L_B565),A
	RET
;
L_938C	LD	A,#0D
	LD	(IY+#07),A
	CALL	L_99C7
	LD	A,#23
	CALL	L_8FE6
	LD	A,(IY+#02)
	BIT	0,A
	RET
;
L_939F	LD	A,(L_B6D8)
	CP	#FF
	JP	Z,L_8A9F
L_93A7	LD	HL,(L_B945)
	LD	DE,#000A
	ADD	HL,DE
	LD	(L_B945),HL
	CALL	L_8A62
	CALL	L_93DC
	JR	NZ,L_93A7
	JR	L_93D3
;
L_93BB	LD	A,(L_B6D8)
	CP	#FF
	RET	Z
L_93C1	LD	HL,(L_B947)
	LD	DE,#000A
	ADD	HL,DE
	LD	(L_B947),HL
	CALL	L_8A6B
	CALL	L_93DC
	JR	NZ,L_93C1
L_93D3	CALL	Pause6060
	CALL	Pause6060
	JP	L_8A35
;
L_93DC	DEC	A
	LD	(L_B6D8),A
	PUSH	AF
	CALL	L_8D09
	CALL	L_9C1A
	POP	AF
	OR	A
	RET
;
L_93EA	PUSH	AF
	PUSH	IY
	LD	A,YL
	LD	IY,L_B559
	CP	#59
	JR	NZ,L_93FB
	LD	IY,L_B562
L_93FB	LD	A,#25
	CALL	L_8FE6
	POP	IY
	LD	A,(L_B6DA)
	CP	#01
	JR	Z,L_9436
	LD	A,(IY+#03)
	LD	L,A
	LD	H,#5E
	LD	DE,#01E0
	ADD	HL,DE
	LD	A,(IY+#02)
	AND	#01
	JR	Z,L_941E
	LD	DE,#0006
	ADD	HL,DE
L_941E	EX	AF,AF' ;'
	XOR	A
	LD	(L_B6E9),A
	LD	DE,L_B7A9
	LD	BC,L_B705
	LD	A,YL
	CP	#62
	JR	Z,L_9432
	LD	BC,L_B6F3
L_9432	EX	AF,AF' ;'
	CALL	L_9438
L_9436	POP	AF
	RET
;
L_9438	LD	(L_B6D9),A
	LD	(L_B6DF),HL
L_943E	LD	A,#01
	LD	(L_B6DA),A
	LD	(L_B6DD),DE
	LD	(L_B6DB),BC
	RET
;
L_944C	LD	A,(L_B6DA)
	OR	A
	RET	Z
	PUSH	BC
	CALL	L_9BF6
	XOR	A
	LD	HL,(L_B6DB)
	AND	A
	LD	BC,#0010
	SBC	HL,BC
	PUSH	HL
	POP	BC
	LD	DE,L_B7ED
	CALL	L_943E
	XOR	A
	LD	(L_B6D9),A
	POP	BC
	RET
;
L_946D	LD	IX,L_B6D9
	LD	A,(IX+#01)
	OR	A
	RET	Z
	INC	A
	JR	Z,L_94D7
	CALL	L_94F9
	CALL	L_94D7
	LD	L,(IX+#04)
	LD	H,(IX+#05)
	LD	C,(HL)
	INC	HL
	LD	B,(HL)
	LD	L,(IX+#06)
	LD	H,(IX+#07)
	BIT	0,C
	CALL	NZ,SubHL_Bmul32
	BIT	1,C
	CALL	NZ,AddHL_Bmul32
	LD	A,(IX+#00)
	CP	#01
	CALL	Z,DecLnoflags
	CALL	NZ,IncLnoflags
	LD	(IX+#06),L
	LD	(IX+#07),H
	LD	A,L
	AND	#1F
	OR	A
	JR	Z,L_952A
	CP	#01
	JR	Z,L_952A
	CP	#1D
	JR	Z,L_952A
	LD	L,(IX+#02)
	LD	H,(IX+#03)
	INC	HL
	LD	A,(HL)
	INC	A
	JR	Z,L_9524
	LD	(IX+#02),L
	LD	(IX+#03),H
	LD	L,(IX+#04)
	LD	H,(IX+#05)
	INC	HL
	INC	HL
	LD	(IX+#04),L
	LD	(IX+#05),H
	RET
;
L_94D7	LD	L,(IX+#02)
	LD	H,(IX+#03)
	LD	A,(HL)
	LD	HL,L_9D00
	LD	(L_91F9),HL
	CALL	L_91EB
	LD	HL,L_C000
	LD	(L_91F9),HL
	CALL	L_950E
	LD	L,(IX+#06)
	LD	H,(IX+#07)
	JP	L_902E
;
L_94F9	LD	A,(L_B562)
	OR	A
	RET	Z
	LD	DE,L_9E80
	LD	A,(L_B6DF)
	AND	#1F
	OR	#E0
	LD	H,#65
	LD	L,A
	JP	L_902E
;
L_950E	LD	A,(IX+#00)
	RRCA
	RRCA
	LD	B,A
	LD	A,(DE)
	AND	#40
	CP	B
	RET	Z
	PUSH	DE
	LD	A,(DE)
	XOR	#40
	LD	(DE),A
	INC	E
	CALL	Mirror24x21
	POP	DE
	RET
;
L_9524	LD	A,#FF
	LD	(IX+#01),A
	RET
;
L_952A	XOR	A
	LD	(IX+#01),A
	RET
;
AddHL_Bmul32
	LD	A,B
	OR	A
	RET	Z
L_9532	LD	DE,#0020
	ADD	HL,DE
	DJNZ	L_9532
	RET
;
SubHL_Bmul32
	LD	A,B
	OR	A
	RET	Z
L_953C	LD	DE,#0020
	SBC	HL,DE
	DJNZ	L_953C
	RET
;
DecLnoflags
	PUSH	AF
	DEC	L
	POP	AF
	RET
;
IncLnoflags
	PUSH	AF
	INC	L
	POP	AF
	RET
;
L_954C	LD	A,(L_B562)
	OR	A
	RET	Z
	LD	A,(L_B565)
	LD	E,A
	LD	D,#5E
	LD	A,(L_B56A)
	PUSH	DE
	LD	HL,L_B8E1
	CALL	GetMHLfromHLplusA
	POP	DE
	LD	L,A
	AND	#3F
	LD	H,A
	LD	A,L
	AND	#C0
	RLCA
	RLCA
	LD	L,A
	LD	A,(L_B564)
	AND	#01
	LD	(L_B6E1),A
	JR	Z,L_957A
	LD	A,#06
	SUB	L
	LD	L,A
L_957A	LD	A,E
	ADD	A,L
	LD	E,A
	LD	B,H
	EX	DE,HL
	LD	DE,#0020
L_9582	ADD	HL,DE
	DJNZ	L_9582
	LD	(L_B6E7),HL
	LD	A,(L_B56A)
	LD	E,A
	LD	D,#00
	LD	HL,L_B873
	ADD	HL,DE
	LD	(L_B6E3),HL
	LD	A,(HL)
	CP	#FF
	RET	Z
	LD	IX,L_B6E1
	JP	L_94D7
;
GetHLfromHLplus2A
	PUSH	DE
	PUSH	HL
	LD	L,A
	LD	H,#00
	ADD	HL,HL
	POP	DE
	ADD	HL,DE
	LD	E,(HL)
	INC	HL
	LD	D,(HL)
	POP	HL
	EX	DE,HL
	RET
;
GetMHLfromHLplusA
	ADD	A,L
	LD	L,A
	JR	NC,L_95B3
	INC	H
L_95B3	LD	A,(HL)
	RET
;
L_95B5	LD	D,(HL)
	INC	HL
	INC	HL
	INC	HL
	BIT	7,D
	RET	NZ
	CP	D
	JR	NZ,L_95B5
	DEC	HL
	LD	D,(HL)
	DEC	HL
	LD	E,(HL)
	RET
;
Mirror24x21
	LD	B,#15
L_95C6	LD	H,#5B
L_95C8	LD	A,(DE)
	LD	L,A
	LD	C,(HL)
	INC	DE
	LD	A,(DE)
	LD	L,A
	LD	A,(HL)
	LD	(DE),A
	INC	DE
	LD	A,(DE)
	LD	L,A
	LD	A,(HL)
	DEC	DE
	DEC	DE
	LD	(DE),A
	INC	DE
	INC	DE
	LD	A,C
	LD	(DE),A
	INC	DE
	DJNZ	L_95C8
	RET
;
L_95DF	LD	B,#0C
L_95E1	LD	A,(IX+#00)
	INC	A
	JR	Z,L_9607
	LD	A,(HL)
	INC	HL
	CALL	L_91EB
	LD	A,(IY+#02)
	AND	#01
	LD	C,A
	LD	A,(DE)
	RLA
	RLA
	RLA
	AND	#01
	CP	C
	JR	Z,L_9607
	LD	A,(DE)
	XOR	#40
	LD	(DE),A
	INC	E
	PUSH	HL
	PUSH	BC
	CALL	Mirror24x21
	POP	BC
	POP	HL
L_9607	INC	IX
	DJNZ	L_95E1
	RET
;
CopyScreenHgt89
	LD	(L_B574),SP
	LD	SP,L_5C08
	LD	HL,L_5E82
	LD	B,#59
	LD	C,#00
L_961A	POP	DE
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	INC	HL
	INC	HL
	INC	HL
	INC	HL
	DJNZ	L_961A
	LD	SP,(L_B574)
	RET
;
FillHL_Bplus1bytes_C
	LD	(HL),C
	INC	HL
	DJNZ	FillHL_Bplus1bytes_C
	LD	(HL),C
	RET
;
IntHandler
	PUSH	AF
	PUSH	BC
	LD	A,(L_B972)
	INC	A
	CP	#09
	JR	Z,L_9673
	LD	(L_B972),A
	JR	L_968E
;
L_9673	XOR	A
	LD	(L_B972),A
	LD	A,(L_B6D8)
	CP	#FF
	JR	Z,L_968E
	OR	A
	JR	Z,L_968E
	LD	B,A
	LD	A,(L_B56B)
	CP	#FF
	LD	A,B
	JR	Z,L_968E
	DEC	A
	LD	(L_B6D8),A
L_968E	POP	BC
	POP	AF
	EI
	RETI

CopyScreenHgt94
	LD	HL,(L_B57B)
	LD	DE,#03F0
	ADD	HL,DE
	LD	DE,L_5E02
	LD	B,#5E
	LD	C,#00
L_96A1	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	LDI
	INC	DE
	INC	DE
	INC	DE
	INC	DE
	DJNZ	L_96A1
	RET
;
FillImgHL_A_BCwh
	PUSH	HL
	PUSH	BC
L_96E2	LD	(HL),A
	INC	HL
	DJNZ	L_96E2
	POP	BC
	POP	HL
	LD	DE,#0020
	ADD	HL,DE
	DEC	C
	JR	NZ,FillImgHL_A_BCwh
	RET
;
FadeOutHL_BCwh
	PUSH	HL
	PUSH	BC
L_96F2	LD	A,(HL)
	AND	#07
	OR	A
	JR	Z,L_96FB
	LD	A,(HL)
	DEC	A
	LD	(HL),A
L_96FB	INC	HL
	DJNZ	L_96F2
	POP	BC
	POP	HL
	LD	DE,#0020
	ADD	HL,DE
	DEC	C
	JR	NZ,FadeOutHL_BCwh
	RET
;
FadeInHL_BCwh
	PUSH	HL
	PUSH	BC
	PUSH	AF
	PUSH	HL
	PUSH	BC
	PUSH	AF
	LD	C,A
L_970F	LD	A,(HL)
	AND	#07
	CP	C
	JR	Z,L_971B
	LD	A,(HL)
	INC	A
	SET	6,A
	LD	(HL),A
	INC	HL
L_971B	DJNZ	L_970F
	POP	AF
	POP	BC
	POP	HL
	LD	DE,#0020
	ADD	HL,DE
	DEC	C
	JR	NZ,FadeInHL_BCwh
	POP	AF
	POP	BC
	POP	HL
	RET
;
L_972B	LD	HL,L_40E2
	LD	B,#02
L_9730	PUSH	BC
	CALL	L_979B
	POP	BC
	DJNZ	L_9730
	LD	B,#02
L_9739	PUSH	BC
	CALL	L_978C
	POP	BC
	DJNZ	L_9739
	LD	B,#03
L_9742	PUSH	BC
	CALL	L_979B
	POP	BC
	DJNZ	L_9742
	LD	B,#08
L_974B	PUSH	BC
	CALL	L_978C
	POP	BC
	DJNZ	L_974B
	XOR	A
	LD	HL,L_5AC2
	LD	BC,#1C01
	CALL	FillImgHL_A_BCwh
	CALL	Pause6060
	XOR	A
	LD	HL,L_5AE5
	LD	BC,#1601
	CALL	FillImgHL_A_BCwh
	JP	Pause6060
;
L_976C	PUSH	HL
	LD	B,#1C
L_976F	XOR	A
	LD	(HL),A
	CALL	GetAttrHigh_AfromH
	LD	E,L
	LD	D,A
	XOR	A
	LD	(DE),A
	INC	HL
	DJNZ	L_976F
	POP	HL
	RET
;
GetAttrHigh_AfromH
	LD	A,H
	RRCA
	RRCA
	RRCA
	AND	#03
	OR	#58
	RET
;
L_9786	PUSH	HL
	LD	B,#1A
	INC	HL
	JR	L_976F
;
L_978C	LD	B,#08
L_978E	PUSH	BC
	CALL	L_976C
	CALL	DownHL
	POP	BC
	DJNZ	L_978E
	JP	Pause6060
;
L_979B	LD	B,#08
	CALL	GetAttrHigh_AfromH
	LD	E,L
	LD	D,A
	LD	A,(DE)
	AND	#C7
	LD	(DE),A
L_97A6	PUSH	BC
	CALL	L_9786
	CALL	DownHL
	POP	BC
	DJNZ	L_97A6
	CALL	GetAttrHigh_AfromH
	LD	E,L
	LD	D,A
	DEC	DE
	DEC	DE
	DEC	DE
	DEC	DE
	DEC	DE
	LD	A,(DE)
	AND	#C7
	LD	(DE),A
	JP	Pause6060
;
L_97C1	LD	HL,(L_B57D)
	PUSH	HL
	LD	DE,(L_B57B)
	LD	HL,L_40E2
	LD	B,#0F
L_97CE	PUSH	BC
	CALL	L_9818
	CALL	L_97F2
	CALL	Pause6060
	POP	BC
	DJNZ	L_97CE
	LD	HL,L_57C2
	CALL	L_97F2
	CALL	Pause6060
	LD	HL,L_57E5
	CALL	L_97F2
	CALL	Pause6060
	POP	HL
	LD	(L_B57D),HL
	RET
;
L_97F2	PUSH	HL
	EXX
	POP	HL
	CALL	UpHL
	CALL	GetAttrHigh_AfromH
	LD	H,A
	EX	DE,HL
	LD	HL,(L_B57D)
L_9800	LD	A,(HL)
	CP	#FF
	JR	Z,L_9812
	LD	B,A
	INC	HL
	LD	A,(HL)
L_9808	LD	(DE),A
	INC	DE
	DJNZ	L_9808
	INC	HL
	LD	(L_B57D),HL
	JR	L_9800
;
L_9812	INC	HL
	LD	(L_B57D),HL
	EXX
	RET
;
L_9818	LD	B,#08
L_981A	PUSH	BC
	PUSH	HL
	CALL	LdirDEtoHL_28b
	POP	HL
	CALL	DownHL
	POP	BC
	DJNZ	L_981A
	RET
;
LdirDEtoHL_28b
	LD	B,#1C
L_9829	LD	A,(DE)
	LD	(HL),A
	INC	HL
	INC	DE
	DJNZ	L_9829
	RET
;
L_9830	LD	A,(IY+#06)
	CP	#1F
	JR	Z,L_985F
	CP	#1D
	JR	Z,L_985F
	CP	#20
	JR	Z,L_985F
	CP	#21
	JR	Z,L_985F
	LD	A,(IY+#08)
	LD	HL,L_F080
	CALL	GetMHLfromHLplusA
	BIT	0,(IY+#02)
	JR	Z,L_9854
	NEG
L_9854	LD	B,(IY+#03)
	ADD	A,B
	CP	#18
	RET	NC
	LD	(IY+#03),A
	RET
;
L_985F	LD	A,(IY+#03)
	INC	A
	LD	(IY+#03),A
	CP	#1E
	RET	NZ
	JP	L_92FF
;
L_986C	CALL	L_9830
	LD	C,B
	LD	A,(L_B6F2)
	LD	B,A
	PUSH	BC
	CALL	L_9BB0
	POP	BC
	LD	A,(L_B9D7)
	OR	A
	RET	NZ
	LD	A,(L_B6F2)
	BIT	7,A
	JR	NZ,L_9886
	RET
;
L_9886	LD	A,(L_B55F)
	CP	#08
	RET	Z
	CP	#1B
	RET	Z
	CP	#1F
	RET	Z
	CP	#1D
	RET	Z
	CP	#21
	RET	Z
	CP	#20
	RET	Z
	LD	A,(L_B568)
	CP	#08
	RET	Z
	CP	#1B
	RET	Z
	CP	#1F
	RET	Z
	CP	#1D
	RET	Z
	CP	#21
	RET	Z
	CP	#20
	RET	Z
	LD	A,#01
	LD	(L_B9D7),A
	LD	A,(L_B55F)
	CP	#11
	JR	Z,L_98D0
	LD	A,(L_B568)
	CP	#11
	JR	Z,L_98DB
L_98C3	XOR	A
	LD	(L_B9D7),A
	LD	A,B
	LD	(L_B6F2),A
	LD	A,C
	LD	(IY+#03),A
	RET
;
L_98D0	LD	A,(L_B56A)
	CP	#08
	RET	Z
	CP	#09
	RET	Z
	JR	L_98C3
;
L_98DB	LD	A,(L_B561)
	CP	#08
	RET	Z
	CP	#09
	RET	Z
	JR	L_98C3
;
L_98E6	LD	B,A
	AND	#03
	LD	A,B
	RET	Z
	BIT	0,(IY+#02)
	RET	Z
	LD	A,B
	XOR	#03
	RET
;
L_98F4	LD	A,(IY+#06)
	LD	HL,L_AED3
	CALL	GetMHLfromHLplusA
	BIT	6,A
	RET	NZ
	LD	A,(L_B9D7)
	OR	A
	RET	NZ
	LD	A,(IY+#01)
	CALL	L_98E6
	BIT	7,(IY+#02)
	RET	NZ
	CALL	L_992B
	CP	#FF
	RET	Z
	CP	(IY+#06)
	RET	Z
L_991A	CALL	L_8FE6
	LD	L,(IY+#04)
	LD	H,(IY+#05)
	DEC	HL
	LD	(IY+#04),L
	LD	(IY+#05),H
	RET
;
L_992B	AND	#0F
	LD	HL,L_B962
	CALL	GetMHLfromHLplusA
	LD	E,A
	LD	D,#00
	BIT	4,(IY+#01)
	JR	NZ,L_9941
	LD	HL,L_AEFB
	JR	L_9944
;
L_9941	LD	HL,L_AF33
L_9944	LD	A,(IY+#06)
	CALL	GetHLfromHLplus2A
	ADD	HL,DE
	LD	A,(HL)
	RET
;
GetMHLfromL_AED3plusA
	PUSH	HL
	PUSH	DE
	LD	HL,L_AED3
	LD	E,A
	LD	D,#00
	ADD	HL,DE
	LD	A,(HL)
	POP	DE
	POP	HL
	RET
;
L_995A	LD	IY,L_B559
	LD	A,(IY+#07)
	AND	#F0
	JR	Z,L_997F
	CALL	L_9995
	PUSH	DE
	PUSH	DE
	LD	B,#1E
	CALL	L_95C6
	POP	DE
	LD	HL,L_4020
	LD	BC,#031E
	CALL	DrawImg_HLscr_BCwh
	POP	DE
	LD	B,#1E
	CALL	L_95C6
L_997F	LD	IY,L_B562
	LD	A,(IY+#07)
	AND	#F0
	RET	Z
	CALL	L_9995
	LD	HL,L_403D
	LD	BC,#031E
	JP	DrawImg_HLscr_BCwh
;
L_9995	LD	A,(IY+#07)
	AND	#F0
	RLCA
	RLCA
	RLCA
	RLCA
	INC	A
	LD	B,A
	RRCA
	RRCA
	RRCA
	RRCA
	LD	C,A
	LD	A,(IY+#07)
	AND	#0F
	OR	C
	LD	(IY+#07),A
	LD	A,B
	CP	#0E
	JR	NZ,L_99BC
	LD	A,(IY+#07)
	AND	#0F
	LD	(IY+#07),A
	XOR	A
L_99BC	LD	HL,L_B9A8
	CALL	GetHLfromHLplus2A
	PUSH	HL
	POP	DE
	LD	A,(DE)
	INC	E
	RET
;
L_99C7	LD	A,YL
	CP	#59
L_99CB	RET	Z
	LD	A,(IY+#07)
	AND	#0F
	DEC	A
	CP	#FF
	JR	Z,L_9A0A
L_99D6	OR	#10
	LD	(IY+#07),A
	AND	#0F
	SRL	A
	LD	HL,L_B6EB
	CALL	GetMHLfromHLplusA
	EX	AF,AF' ;'
	LD	H,#40
	LD	A,YL
	CP	#59
	JR	NZ,L_99F2
	LD	L,#00
	JR	L_99F4
;
L_99F2	LD	L,#1D
L_99F4	LD	B,#03
	EX	AF,AF' ;'
L_99F7	LD	C,A
	AND	#03
	ADD	A,#3A
	PUSH	BC
	PUSH	HL
	CALL	PrintChar88
	POP	HL
	POP	BC
	INC	L
	LD	A,C
	RRA
	RRA
	DJNZ	L_99F7
	RET
;
L_9A0A	LD	A,#1B
	CALL	L_8FE6
	PUSH	IY
	LD	A,YL
	CP	#59
	JR	Z,L_9A1D
	LD	IY,L_B559
	JR	L_9A21
;
L_9A1D	LD	IY,L_B562
L_9A21	LD	A,#24
	CALL	L_8FE6
	POP	IY
	LD	A,#10
	JR	L_99D6
;
L_9A2C	LD	A,(L_B973)
	OR	A
	RET	NZ
	LD	IX,L_B559
	LD	IY,L_B562
	CALL	L_9A44
	LD	IY,L_B559
	LD	IX,L_B562
L_9A44	LD	A,(IX+#08)
	LD	HL,L_AFD7
	CALL	L_95B5
	RET	NZ
	PUSH	DE
	POP	HL
L_9A50	LD	A,(HL)
	CP	#FF
	RET	Z
	CP	(IY+#08)
	CALL	Z,L_9A5E
	INC	HL
	INC	HL
	JR	L_9A50
;
L_9A5E	PUSH	HL
	INC	HL
	LD	A,(HL)
	LD	E,A
	LD	D,#00
	LD	HL,L_B4E4
	ADD	HL,DE
	ADD	HL,DE
	ADD	HL,DE
	LD	A,(HL)
	AND	#03
	LD	C,A
	LD	A,(L_B6F2)
	CP	C
	JR	Z,L_9A9C
	LD	A,(HL)
	AND	#0C
	RRCA
	RRCA
	LD	C,A
	LD	A,(L_B6F2)
	CP	C
	JR	Z,L_9A9C
	LD	A,(HL)
	AND	#30
	RRCA
	RRCA
	RRCA
	RRCA
	LD	C,A
	LD	A,(L_B6F2)
	CP	C
	JR	Z,L_9A9C
	LD	A,(HL)
	AND	#C0
	RLCA
	RLCA
	LD	C,A
	LD	A,(L_B6F2)
	CP	C
	JR	Z,L_9A9C
	JR	L_9ABF
;
L_9A9C	INC	HL
	LD	A,(HL)
	CP	#FF
	JR	Z,L_9AA7
	PUSH	HL
	CALL	L_991A
	POP	HL
L_9AA7	INC	HL
	LD	A,(HL)
	AND	#F0
	OR	A
	JR	Z,L_9AB9
	RRCA
	RRCA
	RRCA
	RRCA
	LD	(L_B6D3),A
	LD	(L_B6D4),IX
L_9AB9	LD	A,(HL)
	AND	#0F
	CALL	NZ,L_99C7
L_9ABF	POP	HL
	RET
;
L_9AC1	CALL	L_9BB0
	LD	IY,L_B562
	CALL	L_8B81
	CALL	L_9B93
	LD	IY,L_B559
	CALL	L_8B81
	CALL	L_9B93
	LD	A,(L_B55F)
	CALL	GetMHLfromL_AED3plusA
	BIT	0,A
	LD	IY,L_B559
	PUSH	IY
	CALL	Z,L_926E
	LD	IY,L_B562
	CALL	NZ,L_926E
	CALL	Z,L_926E
	PUSH	AF
	CALL	L_954C
	POP	AF
	POP	IY
	CALL	NZ,L_926E
	LD	IY,L_B56B
	LD	A,(IY+#00)
	OR	A
	RET	Z
	LD	A,(L_B973)
	OR	A
	JP	NZ,L_926E
	LD	A,(IY+#03)
	INC	A
	AND	#1F
	LD	(IY+#03),A
	CALL	L_92A0
	CALL	L_926E
	LD	IY,L_B559
	LD	A,(IY+#06)
	CP	#08
	JR	Z,L_9B2D
	CP	#1B
	JR	Z,L_9B2D
	JR	L_9B3C
;
L_9B2D	LD	IY,L_B562
	LD	A,#13
	CALL	L_8FE6
	LD	IY,L_B559
	JR	L_9B45
;
L_9B3C	LD	A,#13
	CALL	L_8FE6
	LD	IY,L_B562
L_9B45	LD	B,(IY+#03)
	LD	A,#07
	ADD	A,B
	LD	B,A
	LD	A,(L_B56E)
	CP	B
	JR	NZ,L_9B55
	INC	(IY+#03)
L_9B55	LD	B,A
	LD	A,(L_B6DF)
	AND	#1F
	DEC	A
	AND	#1F
	CP	B
	CALL	Z,L_944C
	LD	A,B
	CP	#1D
	RET	NZ
	XOR	A
	LD	(L_B56B),A
	LD	A,(IY+#02)
	BIT	0,A
	JR	Z,L_9B82
	LD	A,(IY+#06)
	CP	#1B
	JR	Z,L_9B7D
	LD	A,#1D
	JP	L_8FE6
;
L_9B7D	LD	A,#20
	JP	L_8FE6
;
L_9B82	LD	A,(IY+#06)
	CP	#1B
	JR	Z,L_9B8E
	LD	A,#1F
	JP	L_8FE6
;
L_9B8E	LD	A,#21
	JP	L_8FE6
;
L_9B93	LD	A,(IY+#00)
	OR	A
	RET	Z
	LD	A,(L_B973)
	OR	A
	RET	NZ
	CALL	L_98F4
	CALL	L_92A0
	JP	L_986C
;
Pause6060
	LD	BC,0x6060 ;/ret
L_9BA9	DEC	B
	JR	NZ,L_9BA9
	DEC	C
	JR	NZ,L_9BA9
	RET
;
L_9BB0	LD	A,(L_B55B)
	BIT	0,A
	JR	NZ,L_9BC1
	LD	A,(L_B55C)
	LD	B,A
	LD	A,(L_B565)
	SUB	B
	JR	L_9BC9
;
L_9BC1	LD	A,(L_B565)
	LD	B,A
	LD	A,(L_B55C)
	SUB	B
L_9BC9	LD	(L_B6F2),A
	RET
;
PlayNote
	LD	A,(IX+#00)
	OR	A
	RET	Z
	CALL	L_9BD9
	INC	IX
	JR	PlayNote
;
L_9BD9	LD	B,A
	PUSH	BC
	CALL	L_9BE2
	POP	BC
	JP	L_9BEC
;
L_9BE2	DB	#00
	DB	#00
	DB	#00
	DJNZ	L_9BE2
	LD	A,#10
	OUT	(#FE),A
	RET
;
L_9BEC	DB	#00
	DB	#00
	DB	#00
	DJNZ	L_9BEC
	LD	A,#00
	OUT	(#FE),A
	RET
;
L_9BF6	LD	IX,L_BC34
	JR	PlayNote
;
L_9BFC	LD	IX,L_BC48
	JR	PlayNote
;
L_9C02	LD	IX,L_BC52
	JR	PlayNote
;
L_9C08	LD	IX,L_BC1E
	JR	PlayNote
;
L_9C0E	LD	IX,L_BC71
	JR	PlayNote
;
L_9C14	LD	IX,L_BC7B
	JR	PlayNote
;
L_9C1A	LD	IX,L_BC85
	JR	PlayNote
;
L_9C20	LD	A,(L_B973)
	OR	A
	RET	NZ
	LD	A,(L_B9D7)
	OR	A
	RET	Z
	CP	#02
	JR	Z,L_9C55
	LD	A,(L_B561)
	CP	#26
	JR	Z,L_9C3D
	LD	A,(L_B56A)
	CP	#26
	JR	Z,L_9C3D
	RET
;
L_9C3D	LD	A,#22
	LD	IY,L_B559
	CALL	L_8FE6
	LD	A,#22
	LD	IY,L_B562
	CALL	L_8FE6
	LD	A,#02
	LD	(L_B9D7),A
	RET
;
L_9C55	LD	A,(L_B561)
	CP	#10
	RET	NZ
	XOR	A
	LD	(L_B9D7),A
	LD	IY,L_B559
	BIT	0,A
	CALL	L_9C8D
	CALL	Z,L_9C82
	CALL	NZ,L_9C77
	LD	IY,L_B562
	CALL	L_9C8D
	JR	Z,L_9C82
L_9C77	PUSH	AF
	LD	A,(IY+#03)
	SUB	#02
	LD	(IY+#03),A
	POP	AF
	RET
;
L_9C82	PUSH	AF
	LD	A,(IY+#03)
	ADD	A,#02
	LD	(IY+#03),A
	POP	AF
	RET
;
L_9C8D	XOR	A
	CALL	L_8FE6
	LD	A,(IY+#02)
	XOR	#01
	LD	(IY+#02),A
	BIT	0,A
	RET
;
L_9C9C	LD	A,(L_B973)
	INC	A
	LD	(L_B973),A
	CP	#02
	RET	NZ
	XOR	A
	LD	(L_B973),A
	RET
;
;#9CAB
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00       ;.....
L_9D00       DB       #DA,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;Z.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#E0,#7F,#FF,#DF,#9F,#FF,#BF       ;.`.._..?
       DB       #E0,#FE,#7F,#F0,#F9,#FF,#CE,#F7       ;`~.py.Nw
       DB       #BF,#FF,#EF,#DF,#7E,#DF,#EB,#FF       ;?.o_~_k.
       DB       #DD,#FF,#FF,#BB,#FF,#EF,#BD,#FF       ;]..;.o=.
       DB       #DE,#9E,#7F,#FF,#9F,#FF,#FF,#7F       ;^.......
       DB       #FF,#FF,#81,#FF,#FF,#FE,#01,#FF       ;.....~..
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#F0       ;.......p
       DB       #7F,#FF,#EB,#BF,#FF,#17,#DF,#FC       ;..k?.._|
       DB       #FB,#DF,#FB,#FD,#EF,#F7,#FE,#EF       ;{_{}ow~o
       DB       #F7,#FF,#2F,#F7,#FC,#DF,#FB,#E1       ;w./w|_{a
       DB       #5F,#FB,#E1,#3F,#FC,#A1,#7F,#FE       ;_{a?|!.~
       DB       #67,#7F,#FE,#D8,#FF,#FF,#07,#FF       ;g.~X....
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#F7,#FF,#FF,#CB,#FF,#FF,#BD       ;.w..K..=
       DB       #FF,#FF,#BE,#FF,#FF,#5F,#7F,#FF       ;..>.._..
       DB       #3F,#7F,#FE,#6F,#BF,#FD,#EF,#9F       ;?.~o?}o.
       DB       #FC,#8F,#AF,#FD,#03,#6F,#FE,#C2       ;|./}.o~B
       DB       #EF,#FF,#41,#EF,#FF,#7B,#EF,#FF       ;o.Ao.{o.
       DB       #8D,#DF,#FF,#F7,#BF,#FF,#F8,#7F       ;._.w?.x.
       DB       #C1,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;A.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#C1,#FF,#FE,#3E,#FF,#F1,#FF       ;.A.~>.q.
       DB       #1F,#EF,#0F,#EF,#EE,#1F,#F7,#EE       ;.o.on.wn
       DB       #1E,#F7,#EE,#1E,#FB,#F6,#0F,#7D       ;.wn.{v.}
       DB       #EF,#1F,#FD,#DF,#FF,#FE,#B8,#7B       ;o.}_.~8{
       DB       #FE,#38,#07,#FE,#78,#3B,#F7,#64       ;~8.~x;wd
       DB       #7F,#EF,#60,#7F,#FF,#50,#FF,#DE       ;.o`..P.^
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#E0       ;.......`
       DB       #FF,#FF,#1B,#7F,#FE,#E6,#7F,#FE       ;....~f.~
       DB       #85,#3F,#FC,#87,#DF,#FA,#87,#DF       ;.?|._z._
       DB       #FB,#3F,#EF,#F4,#FF,#EF,#F7,#7F       ;{?ot.ow.
       DB       #EF,#F7,#BF,#DF,#FB,#DF,#3F,#FB       ;ow?_{_?{
       DB       #E8,#FF,#FD,#D7,#FF,#FE,#0F,#FF       ;h.}W.~..
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FE,#1F,#FF,#FD,#EF       ;...~..}o
       DB       #FF,#FB,#B1,#FF,#F7,#DE,#FF,#F7       ;.{1.w^.w
       DB       #82,#FF,#F7,#43,#7F,#F6,#C0,#BF       ;..wC.v@?
       DB       #F5,#F1,#3F,#F9,#F7,#BF,#FD,#F6       ;uq?yw?}v
       DB       #7F,#FE,#FC,#FF,#FE,#FA,#FF,#FF       ;.~|.~z..
       DB       #7D,#FF,#FF,#BD,#FF,#FF,#C3,#FF       ;}..=..C.
L_9E80       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#87,#FF,#FC,#78,#FF,#FB       ;....|x.{
       DB       #FF,#7F,#FB,#FF,#7F,#FC,#FC,#FF       ;..{..||.
       DB       #01,#82,#7F,#FF,#CF,#BF,#FF,#FF       ;....O?..
       DB       #DF,#FF,#77,#EF,#FF,#7F,#6F,#FF       ;_.wo..o.
       DB       #BF,#1F,#FF,#DF,#EF,#FF,#FD,#EF       ;?.._o.}o
       DB       #FF,#FE,#9F,#FF,#FF,#EF,#FF,#FF       ;.~...o..
       DB       #EF,#FF,#F9,#0F,#FF,#6F,#F3,#FF       ;o.y..os.
       DB       #5D,#8D,#FF,#5A,#C2,#FF,#B7,#42       ;]..ZB.7B
       DB       #FF,#BA,#C1,#7F,#AD,#91,#7F,#57       ;.:A.-..W
       DB       #11,#BF,#53,#30,#BF,#D2,#70,#BF       ;.?S0?Rp?
       DB       #03,#F4,#13,#FF,#F6,#7D,#FF,#F7       ;.t..v}.w
       DB       #FE,#FF,#FB,#BF,#7F,#FB,#FB,#7F       ;~.{?.{{.
       DB       #F5,#F8,#FF,#F6,#FF,#7F,#F7,#EF       ;ux.v..wo
       DB       #7F,#F7,#F4,#FF,#F7,#FF,#7F,#F7       ;.wt.w..w
       DB       #FF,#7F,#F7,#F0,#FF,#F7,#0F,#FF       ;..wp.w..
       DB       #F8,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;x.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#A0,#9F,#FF,#B3,#EF,#FF,#BF       ;. ..3o.?
       DB       #F7,#FF,#DD,#FB,#FF,#DF,#DB,#FF       ;w.]{._[.
       DB       #AF,#C7,#FF,#B7,#FB,#FF,#BF,#7B       ;/G.7{.?{
       DB       #FF,#BF,#A7,#FF,#BF,#FB,#FF,#BF       ;.?'.?{.?
       DB       #FB,#FF,#BC,#07,#FF,#C3,#FF,#FF       ;{.<..C..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#D0,#5F,#FF,#D9,#DF,#FF,#DF       ;.P_.Y_._
       DB       #DF,#FF,#EE,#EF,#FF,#EF,#F7,#FF       ;_.no.ow.
       DB       #D7,#EB,#FF,#DB,#FD,#FF,#DF,#BD       ;Wk.[}._=
       DB       #FF,#DF,#D3,#FF,#DF,#FD,#FF,#DF       ;._S._}._
       DB       #FD,#FF,#D9,#E1,#FF,#E0,#1F,#FF       ;}.Ya.`..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#E8,#27,#FF,#EC,#FB,#FF,#EF       ;.h'.l{.o
       DB       #FD,#FF,#F7,#7E,#FF,#F7,#F6,#FF       ;}.w~.wv.
       DB       #EB,#F1,#FF,#ED,#FE,#FF,#EF,#DE       ;kq.m~.o^
       DB       #FF,#EF,#E9,#FF,#DF,#FE,#FF,#DF       ;.oi._~._
       DB       #FE,#FF,#DF,#21,#FF,#E0,#1F,#FF       ;~._!.`..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #80,#FF,#FF,#41,#3F,#FF,#67,#DF       ;...A?.g_
       DB       #FF,#7F,#EF,#FF,#BB,#F7,#FF,#BF       ;..o.;w.?
       DB       #B7,#FF,#5F,#8F,#FF,#6F,#F7,#FF       ;7._..ow.
       DB       #7E,#F7,#FF,#7F,#4F,#FF,#7F,#F7       ;~w..O..w
       DB       #FE,#FF,#EF,#FE,#FF,#1F,#FE,#FC       ;~.o~..~|
       DB       #FF,#FF,#0F,#7F,#FF,#F0,#FF,#FF       ;.....p..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#BE,#FF,#FF,#59,#3F       ;...>..Y?
       DB       #FF,#67,#DF,#FF,#7F,#EF,#FF,#BB       ;.g_..o.;
       DB       #F7,#FF,#BF,#B7,#FF,#5F,#8F,#FF       ;w.?7._..
       DB       #6F,#F7,#FF,#7E,#EF,#FF,#7F,#5F       ;ow.~o.._
       DB       #FF,#7F,#DF,#FF,#7F,#BF,#FF,#71       ;.._..?.q
       DB       #7F,#FF,#8E,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#E0,#FF,#FF       ;.....`..
       DB       #D0,#FF,#FF,#DA,#FF,#FF,#DE,#FF       ;P..Z..^.
       DB       #FF,#DE,#FF,#FF,#DE,#FF,#FF,#DE       ;.^..^..^
       DB       #FF,#FF,#BE,#FF,#FF,#BE,#FF,#FF       ;..>..>..
       DB       #BE,#FF,#FF,#7E,#FF,#FF,#7D,#FF       ;>..~..}.
       DB       #FF,#70,#FF,#FE,#C0,#FF,#FD,#00       ;.p.~@.}.
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#07,#FF,#FF,#0B,#FF       ;........
       DB       #FF,#5B,#FF,#FF,#7B,#FF,#FF,#7B       ;.[..{..{
       DB       #FF,#FF,#7B,#FF,#FF,#7B,#FF,#FF       ;..{..{..
       DB       #7D,#FF,#FF,#7D,#FF,#FF,#7D,#FF       ;}..}..}.
       DB       #FF,#7E,#FF,#FF,#BE,#FF,#FF,#0E       ;.~..>...
       DB       #FF,#FF,#03,#7F,#FF,#00,#BF,#FF       ;......?.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FD,#FF,#FF,#FA       ;....}..z
       DB       #FF,#FF,#F6,#7F,#FF,#EE,#8F,#FF       ;..v..n..
       DB       #8E,#F7,#FF,#6F,#EB,#FC,#FF,#EB       ;.w.ok|.k
       DB       #FB,#FF,#F7,#FB,#FF,#6F,#FD,#FB       ;{.w{.o}{
       DB       #1F,#FD,#FF,#DF,#FE,#FD,#BF,#FF       ;.}._~}?.
       DB       #7E,#7F,#FF,#A6,#FF,#FF,#D9,#FF       ;~..&..Y.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FB,#FF,#FF,#E5       ;....{..e
       DB       #FF,#FF,#DE,#FF,#FF,#9F,#7F,#FF       ;..^.....
       DB       #7F,#BF,#FF,#7F,#BF,#FE,#FE,#DF       ;.?..?~~_
       DB       #FD,#FF,#8F,#FD,#DB,#F7,#FE,#3F       ;}..}[w~?
       DB       #FB,#FF,#79,#BD,#FF,#B7,#C3,#FF       ;{.y=.7C.
       DB       #CF,#DF,#FF,#F6,#5F,#FF,#F9,#BF       ;O_.v_.y?
       DB       #03,#FF,#FF,#FF,#FC,#3F,#FF,#F2       ;....|?.r
       DB       #4F,#FF,#E8,#10,#7F,#C1,#68,#BF       ;O.h..Ah?
       DB       #D0,#BA,#7F,#84,#F4,#7F,#A1,#6A       ;P:..t.!j
       DB       #BF,#83,#BC,#7F,#95,#68,#7F,#80       ;?.<..h..
       DB       #94,#BF,#89,#20,#7F,#C0,#02,#7F       ;.?. .@..
       DB       #D2,#08,#7F,#E0,#00,#BF,#FF,#A0       ;R..`.?. 
       DB       #7F,#FF,#DF,#FF,#FF,#FF,#FF,#FF       ;.._.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FB       ;.......{
       DB       #FF,#FF,#F4,#3F,#FF,#EE,#DF,#FF       ;..t?.n_.
       DB       #D7,#6F,#FF,#BB,#F7,#FF,#3F,#F7       ;Wo.;w.?w
       DB       #FE,#DE,#F7,#FE,#EF,#EF,#FD,#DE       ;~^w~oo}^
       DB       #DF,#FE,#FF,#BF,#FE,#FF,#BF,#FF       ;_~.?~.?.
       DB       #7F,#7F,#FF,#97,#7F,#FF,#EE,#FF       ;......n.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#E3       ;.......c
       DB       #FF,#FF,#D4,#FF,#FF,#3F,#7F,#FE       ;..T..?.~
       DB       #DE,#3F,#F8,#F9,#DF,#F7,#FF,#DF       ;^?xy_w._
       DB       #FB,#FF,#8F,#FC,#7D,#77,#FF,#5F       ;{..|}w._
       DB       #F7,#FF,#BF,#EF,#FF,#DF,#AF,#FF       ;w.?o._/.
       DB       #EF,#9F,#FF,#F7,#BF,#FF,#F8,#7F       ;o..w?.x.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#F8       ;.......x
       DB       #0F,#FF,#F4,#13,#FF,#F6,#7D,#FF       ;..t..v}.
       DB       #F7,#FE,#FF,#FB,#BF,#7F,#FB,#FB       ;w~.{?.{{
       DB       #7F,#F5,#F8,#FF,#F6,#FF,#7F,#F7       ;.ux.v..w
       DB       #EF,#7F,#F7,#F4,#FF,#F7,#FF,#7F       ;o.wt.w..
       DB       #F7,#EF,#7F,#F7,#AC,#FF,#EF,#9D       ;wo.w,.o.
       DB       #FF,#F0,#06,#FF,#FF,#CB,#7F,#FF       ;.p...K..
       DB       #DD,#BF,#FF,#EA,#BF,#FF,#F7,#BF       ;]?.j?.w?
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FE       ;.......~
       DB       #FF,#FF,#F1,#1F,#FF,#E8,#2F,#FF       ;..q..h/.
       DB       #F2,#53,#FF,#F0,#85,#FF,#F5,#C1       ;rS.p..uA
       DB       #FF,#F0,#A5,#FF,#F0,#03,#FF,#EA       ;.p%.p..j
       DB       #03,#FF,#F0,#4B,#FF,#FF,#87,#FF       ;..pK....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FD,#FF,#FF       ;.....}..
       DB       #FA,#FF,#FF,#FA,#FF,#FF,#FB,#9F       ;z..z..{.
       DB       #7F,#FB,#9B,#7F,#FB,#98,#FF,#FB       ;.{..{..{
       DB       #CF,#7F,#F7,#CF,#7F,#F7,#C4,#FF       ;O.wO.wD.
       DB       #F7,#C3,#7F,#F7,#E1,#7F,#F7,#E1       ;wC.wa.wa
       DB       #7F,#F9,#F1,#7F,#FF,#FF,#FF,#FF       ;.yq.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#87,#FF,#FF,#79,#FF       ;......y.
       DB       #FF,#7E,#FF,#FE,#BF,#7F,#FD,#FB       ;.~.~?.}{
       DB       #7F,#FB,#F8,#FF,#F7,#FF,#7F,#EF       ;.{x.w..o
       DB       #EF,#7F,#F7,#F4,#FF,#FB,#9F,#7F       ;o.wt.{..
       DB       #FD,#2F,#7F,#FE,#D8,#FF,#FF,#77       ;}/.~X..w
       DB       #FF,#FF,#5B,#FF,#FE,#BD,#FF,#FF       ;..[.~=..
       DB       #55,#FF,#FF,#AB,#FF,#FF,#D7,#FF       ;U..+..W.
       DB       #03,#FF,#FF,#FF,#FF,#C1,#FF,#FF       ;.....A..
       DB       #3E,#7F,#F0,#FF,#BF,#EE,#FF,#DF       ;>.p.?n._
       DB       #F7,#FF,#5F,#FB,#FF,#1F,#FC,#FF       ;w._{..|.
       DB       #EF,#FD,#BD,#EF,#FD,#FE,#9F,#FE       ;o}=o}~.~
       DB       #FF,#EF,#FE,#FD,#EF,#FE,#FF,#1F       ;.o~}o~..
       DB       #FE,#FC,#FF,#FF,#7D,#FF,#FF,#83       ;~|..}...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#C0,#7F,#FF,#A0,#9F,#FF,#B3       ;.@.. ..3
       DB       #EF,#FF,#BF,#F7,#FF,#DD,#FB,#FF       ;o.?w.]{.
       DB       #DF,#DB,#FF,#AF,#C7,#FF,#B7,#FB       ;_[./G.7{
       DB       #FF,#BF,#7B,#FF,#BF,#A7,#FF,#BF       ;.?{.?'.?
       DB       #FB,#FF,#BF,#FB,#FF,#BF,#47,#FF       ;{.?{.?G.
       DB       #BE,#DF,#FF,#C0,#3F,#FF,#FF,#FF       ;>_.@?...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #43,#FE,#FF,#7E,#FE,#7F,#9E,#C0       ;C~.~~..@
       DB       #3F,#DE,#BF,#15,#1E,#43,#DF,#CE       ;?^?..C_N
       DB       #8D,#FF,#FE,#B0,#5F,#FD,#C0,#9C       ;..~0_}@.
       DB       #CB,#FE,#93,#FB,#FE,#1F,#FB,#FF       ;K~.{~.{.
       DB       #DF,#FB,#FF,#BF,#FB,#FF,#BB,#FB       ;_{.?{.;{
       DB       #FF,#BE,#FB,#FF,#BD,#FB,#FF,#7B       ;.>{.={.{
       DB       #EB,#FF,#7B,#F7,#FF,#7B,#F7,#FF       ;k.{w.{w.
       DB       #7F,#F7,#FF,#7F,#F7,#FF,#7F,#F7       ;.w..w..w
       DB       #03,#D0,#4F,#FF,#D9,#F7,#FF,#DF       ;.PO.Yw._
       DB       #FB,#FF,#EE,#FD,#FF,#EF,#ED,#FF       ;{.n}.om.
       DB       #D7,#E3,#FF,#DB,#FD,#FF,#DF,#BD       ;Wc.[}._=
       DB       #FF,#DF,#D3,#FF,#BF,#FD,#FF,#BF       ;._S.?}.?
       DB       #FD,#FF,#BF,#23,#FF,#C0,#DF,#FF       ;}.?#.@_.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #01,#00,#FF,#FF,#41,#3F,#FF,#67       ;....A?.g
       DB       #DF,#FF,#7F,#EF,#FF,#BB,#F7,#FF       ;_..o.;w.
       DB       #BF,#B7,#FF,#5F,#8F,#FF,#6F,#F7       ;?7._..ow
       DB       #FF,#7E,#F7,#FF,#7F,#4F,#FF,#FF       ;.~w..O..
       DB       #F7,#FF,#FD,#F7,#FF,#F9,#0F,#FF       ;w.}w.y..
       DB       #1F,#7F,#FF,#0A,#BF,#FF,#03,#5F       ;....?.._
       DB       #FF,#12,#EF,#FF,#33,#6F,#FF,#79       ;..o.3o.y
       DB       #D7,#FF,#E4,#57,#FF,#F3,#D7,#FF       ;W.dW.sW.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #BF,#FF,#F0,#47,#FF,#E8,#FB,#FF       ;?.pG.h{.
       DB       #EF,#7D,#FF,#EF,#B0,#FF,#F7,#FF       ;o}.o0.w.
       DB       #7F,#F5,#FE,#7F,#F7,#FF,#BF,#FB       ;.u~.w.?{
       DB       #FF,#BF,#FB,#FB,#7F,#FB,#FA,#7F       ;.?{{.{z.
       DB       #F7,#1F,#BF,#EC,#06,#DF,#E8,#02       ;w.?l._h.
       DB       #AF,#D8,#23,#77,#D0,#30,#EB,#B0       ;/X#wP0k0
       DB       #3C,#0D,#A0,#4F,#19,#60,#F8,#EE       ;<. O.`xn
       DB       #03,#E8,#27,#FF,#EC,#FB,#FF,#EF       ;.h'.l{.o
       DB       #FD,#FF,#F7,#7E,#FF,#F7,#F6,#FF       ;}.w~.wv.
       DB       #EB,#F1,#FF,#ED,#FE,#FF,#EF,#DE       ;kq.m~.o^
       DB       #FF,#EF,#E9,#FF,#DF,#FE,#FF,#DF       ;.oi._~._
       DB       #7E,#FF,#D7,#91,#FF,#E0,#77,#FF       ;~.W..`w.
       DB       #FF,#8F,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #C0,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;@.......
       DB       #FF,#FF,#FF,#C3,#FF,#FF,#3D,#FF       ;...C..=.
       DB       #FE,#C2,#FF,#FD,#02,#3F,#FA,#62       ;~B.}.?zb
       DB       #5F,#FA,#C2,#5F,#F4,#04,#5F,#F4       ;_zB_t._t
       DB       #22,#DF,#FB,#CA,#DF,#FC,#D3,#DF       ;"_{J_|S_
       DB       #FD,#17,#9F,#FD,#FE,#9F,#01,#FF       ;}..}~...
       DB       #EF,#C3,#FF,#F7,#FE,#FD,#FB,#FE       ;oC.w~}{~
       DB       #FF,#FB,#7E,#FE,#FB,#00,#FE,#FD       ;.{~~{.~}
       DB       #BD,#FD,#90,#4F,#FD,#99,#F7,#FD       ;=}.O}.w}
       DB       #5F,#FB,#FE,#AF,#FD,#FE,#AF,#ED       ;_{~/}~/m
       DB       #FE,#B7,#E3,#FF,#57,#FD,#FF,#57       ;~7c.W}.W
       DB       #BD,#FF,#57,#D3,#FF,#AB,#FD,#FF       ;=.WS.+}.
       DB       #AB,#FD,#FE,#6D,#70,#FD,#B5,#1F       ;+}~mp}5.
       DB       #FA,#14,#E1,#F4,#15,#B0,#F4,#0B       ;z.at.0t.
       DB       #58,#EA,#0A,#E8,#D0,#4B,#59,#D0       ;Xj.hPKYP
       DB       #65,#B1,#A0,#75,#E1,#A1,#DF,#BF       ;e1 ua!_?
       DB       #BE,#FF,#EC,#1D,#FF,#EC,#3B,#FF       ;>.l..l;.
       DB       #ED,#BB,#FF,#EF,#B8,#FF,#DF,#F5       ;m;.o8._u
       DB       #FF,#97,#FF,#FF,#77,#FE,#F0,#77       ;....w~pw
       DB       #ED,#EF,#F7,#6D,#D0,#F7,#F3,#A0       ;mowmPws 
       DB       #77,#BB,#40,#37,#D7,#80,#36,#CF       ;w;@7W.6O
       DB       #01,#37,#3F,#07,#36,#BF,#0F,#36       ;.7?.6?.6
       DB       #5F,#1B,#26,#5F,#39,#BB,#5F,#7C       ;_.&_9;_|
       DB       #E5,#5F,#1E,#7F,#5F,#07,#F1,#DF       ;e_.._.q_
       DB       #03,#FE,#8E,#2F,#FE,#DF,#6F,#FE       ;.~./~_o~
       DB       #FF,#EF,#FF,#7F,#DF,#FF,#4E,#5F       ;.o.._.N_
       DB       #FF,#64,#DF,#FF,#7F,#DF,#FF,#7F       ;.d_.._..
       DB       #DF,#FF,#71,#DF,#FE,#FF,#EF,#FC       ;_.q_~.o|
       DB       #FF,#EF,#FB,#E0,#F7,#FC,#2E,#8F       ;.o{`w|..
       DB       #FF,#DB,#7F,#FF,#B5,#BF,#FF,#AE       ;.[..5?..
       DB       #BF,#FF,#B5,#BF,#FF,#DB,#7F,#FF       ;?.5?.[..
       DB       #EE,#FF,#FF,#F1,#FF,#FF,#FF,#FF       ;n..q....
       DB       #03,#F9,#D9,#FF,#F7,#9A,#FF,#EF       ;.yY.w..o
       DB       #FF,#7F,#F7,#F7,#7F,#EF,#DF,#03       ;..ww.o_.
       DB       #9F,#FF,#BD,#7D,#FE,#D6,#87,#E1       ;..=}~V.a
       DB       #6E,#F7,#C0,#56,#F9,#80,#7E,#FD       ;nw@Vy.~}
       DB       #00,#01,#FE,#FF,#FF,#FF,#FF,#FF       ;..~.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #03,#FF,#FD,#FF,#FF,#02,#7F,#FE       ;..}....~
       DB       #CF,#BF,#FE,#FF,#DF,#FE,#77,#EF       ;O?~._~wo
       DB       #FE,#7F,#6F,#FE,#BF,#1F,#FE,#DF       ;~.o~?.~_
       DB       #EF,#FE,#FD,#EF,#FE,#FE,#9F,#FE       ;o~}o~~.~
       DB       #FF,#EF,#FE,#FF,#EF,#FE,#F9,#1F       ;.o~.o~y.
       DB       #FF,#77,#7F,#FF,#5D,#BF,#FF,#5A       ;.w..]?.Z
       DB       #DF,#FF,#B7,#5F,#FF,#BA,#DF,#FF       ;_.7_.:_.
       DB       #AD,#BF,#FF,#C7,#7F,#FF,#F8,#FF       ;-?.G..x.
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FC,#1F       ;......|.
       DB       #FF,#F3,#EF,#FF,#CC,#17,#FF,#B0       ;.so.L..0
       DB       #CB,#FE,#70,#6B,#FD,#80,#0B,#FA       ;K~pk}..z
       DB       #28,#CB,#F4,#00,#7B,#F4,#82,#0B       ;(Kt.{t..
       DB       #03,#D2,#1B,#F7,#A4,#22,#0F,#A4       ;.R.w$".$
       DB       #21,#7F,#A4,#31,#7F,#A4,#7E,#FF       ;!.$1.$~.
       DB       #D4,#C3,#7F,#D4,#80,#BF,#D4,#80       ;TC.T.?T.
       DB       #5F,#D4,#E0,#5F,#EC,#98,#5F,#F5       ;_T`_l._u
       DB       #8C,#BF,#85,#8F,#BF,#65,#8F,#7F       ;.?..?e..
       DB       #7B,#0F,#7F,#47,#0F,#7F,#BE,#3E       ;{..G..>>
       DB       #FF,#C2,#6E,#7F,#C4,#DF,#9F,#BC       ;.Bn.D_.<
       DB       #3F,#EF,#7C,#08,#1F,#8F,#FD,#FF       ;?o|...}.
       DB       #03,#D2,#1B,#F7,#A4,#22,#0F,#A4       ;.R.w$".$
       DB       #21,#7F,#A4,#31,#7F,#A4,#7E,#FF       ;!.$1.$~.
       DB       #D4,#C3,#7F,#D4,#80,#BF,#D4,#80       ;TC.T.?T.
       DB       #5F,#D4,#9E,#5F,#EC,#A1,#5F,#F5       ;_T._l!_u
       DB       #A1,#DF,#85,#E0,#BF,#65,#F0,#5F       ;!_.`?ep_
       DB       #7B,#F8,#5F,#47,#C4,#5F,#BF,#84       ;{x_GD_?.
       DB       #BF,#CF,#04,#BF,#DF,#84,#CF,#BF       ;?O.?_.O?
       DB       #FC,#37,#C0,#FC,#0B,#FF,#0F,#FF       ;|7@|....
       DB       #03,#E0,#3F,#FF,#7B,#DF,#FF,#3D       ;.`?.{_.=
       DB       #EF,#FF,#7F,#EF,#FF,#7F,#EF,#FF       ;o..o..o.
       DB       #FD,#EF,#FF,#7E,#EF,#FF,#67,#DF       ;}o.~o.g_
       DB       #FF,#B6,#DF,#FF,#D6,#DF,#FF,#E0       ;.6_.V_.`
       DB       #3F,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;?.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #43,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;C.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#C3       ;.......C
       DB       #FF,#FF,#3C,#FF,#FE,#FF,#7F,#FE       ;..<.~..~
       DB       #FF,#BF,#FE,#EF,#BF,#FD,#C7,#DF       ;.?~o?}G_
       DB       #FD,#5F,#BF,#FD,#87,#DF,#FD,#83       ;}_?}._}.
       DB       #DF,#FD,#A7,#DF,#FD,#CF,#DF,#FB       ;_}'_}O_{
       DB       #F7,#EF,#FB,#C7,#EF,#F6,#0E,#2F       ;wo{Gov./
       DB       #43,#E8,#10,#17,#D8,#20,#17,#B8       ;Ch..X .8
       DB       #C0,#0B,#BD,#E9,#8B,#DF,#F1,#8B       ;@.=i._q.
       DB       #E9,#E3,#45,#E8,#02,#45,#F4,#04       ;icEh.Et.
       DB       #25,#F4,#08,#25,#EC,#10,#45,#E8       ;%t.%l.Eh
       DB       #70,#8B,#DC,#C9,#17,#D7,#86,#6F       ;p.\I.W.o
       DB       #B7,#08,#9F,#57,#12,#7F,#56,#12       ;7..W..V.
       DB       #FF,#76,#0D,#FF,#72,#0B,#FF,#B2       ;.v..r..2
       DB       #0B,#FF,#94,#0B,#FF,#D4,#17,#FF       ;.....T..
       DB       #43,#EC,#17,#FF,#F4,#37,#FF,#F4       ;Cl..t7.t
       DB       #77,#FF,#F0,#57,#FF,#F0,#97,#FF       ;w.pW.p..
       DB       #E8,#D7,#FF,#E8,#57,#FF,#F4,#37       ;hW.hW.t7
       DB       #FF,#FA,#37,#FF,#FA,#2B,#FF,#FD       ;.z7.z+.}
       DB       #25,#FF,#FD,#15,#FF,#FE,#95,#FF       ;%.}..~..
       DB       #FE,#8D,#FF,#FF,#45,#FF,#FF,#45       ;~...E..E
       DB       #FF,#FF,#4A,#FF,#FF,#4A,#FF,#FE       ;..J..J.~
       DB       #4A,#FF,#F1,#9B,#3F,#EF,#FF,#DF       ;J.q.?o._
       DB       #43,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;C.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#F5,#FF       ;......u.
       DB       #FF,#CA,#7F,#FF,#BF,#BF,#FF,#BF       ;.J..??.?
       DB       #DF,#FF,#7D,#DF,#FE,#F8,#5F,#FF       ;_.}_~x_.
       DB       #76,#5F,#FE,#F8,#3F,#FE,#F8,#BF       ;v_~x?~x?
       DB       #C3,#FD,#BC,#3F,#FE,#FD,#4F,#FD       ;C}<?~}O}
       DB       #FF,#53,#FE,#C7,#0C,#FE,#80,#83       ;.S~G.~..
       DB       #FD,#00,#41,#FD,#10,#31,#FA,#1A       ;}.A}.1z.
       DB       #3D,#FA,#29,#FF,#FA,#24,#7D,#FA       ;=z).z$}z
       DB       #46,#01,#F4,#C7,#80,#F4,#87,#DD       ;F.tG.t.]
       DB       #E9,#05,#F3,#E9,#05,#61,#EA,#0F       ;i.si.aj.
       DB       #60,#D2,#0A,#60,#D4,#1A,#60,#B4       ;`R.`T.`4
       DB       #34,#30,#04,#FE,#38,#7F,#FF,#FF       ;40.~8...
       DB       #42,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;B.......
       DB       #FF,#FF,#FF,#FF,#FF,#7F,#FF,#FF       ;........
       DB       #BF,#FF,#FF,#DF,#FF,#FF,#DF,#FF       ;?.._.._.
       DB       #FF,#9F,#FF,#FF,#00,#0F,#FF,#00       ;........
       DB       #97,#FF,#03,#0B,#FF,#0C,#05,#FF       ;........
       DB       #B0,#42,#FF,#C0,#C1,#7F,#01,#E0       ;0B.@A..`
       DB       #9F,#03,#98,#67,#0E,#3E,#19,#3F       ;...g.>.?
       DB       #FF,#85,#FF,#FF,#C2,#FE,#00,#FE       ;....B~.~
       DB       #43,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;C.......
       DB       #FF,#FF,#FF,#F0,#FF,#FF,#CF,#7F       ;...p..O.
       DB       #FF,#B0,#BF,#FF,#40,#87,#FE,#98       ;.0?.@.~.
       DB       #97,#FE,#B0,#97,#FD,#01,#17,#FD       ;.~0.}..}
       DB       #11,#77,#FE,#E5,#77,#FE,#89,#F7       ;.w~ew~.w
       DB       #FE,#F7,#F7,#FF,#07,#C7,#FF,#EF       ;~ww..G.o
       DB       #BB,#FF,#EF,#FD,#FF,#DF,#FD,#FF       ;;.o}._}.
       DB       #DF,#FD,#FF,#DF,#FD,#FF,#BE,#7D       ;_}._}.>}
       DB       #43,#18,#3D,#7B,#7D,#BF,#7B,#5F       ;C.={}?{_
       DB       #BF,#7B,#53,#BF,#DB,#80,#3F,#3B       ;?{S?[.?;
       DB       #FF,#BE,#FB,#FF,#DD,#F7,#FF,#DB       ;.>{.]w.[
       DB       #EB,#FF,#E7,#EB,#FF,#CF,#DB,#FF       ;k.gk.O[.
       DB       #3F,#BB,#FE,#F7,#BB,#FD,#C7,#7B       ;?;~w;}G{
       DB       #FE,#D6,#FB,#FF,#3D,#FB,#FF,#BF       ;~V{.={.?
       DB       #FB,#FF,#BF,#EB,#FF,#7B,#F7,#FF       ;{.?k.{w.
       DB       #7B,#F7,#FF,#7F,#F7,#FF,#7F,#F7       ;{w..w..w
       DB       #43,#FE,#FB,#F7,#FE,#FF,#F7,#FE       ;C~{w~.w~
       DB       #FF,#D7,#FE,#FB,#E7,#FE,#FF,#D7       ;.W~{g~.W
       DB       #FE,#FB,#FB,#FE,#FB,#FB,#FE,#FB       ;~{{~{{~{
       DB       #FB,#FE,#FB,#FB,#FE,#FB,#FB,#FE       ;{~{{~{{~
       DB       #FB,#FB,#FE,#FB,#FB,#FE,#F9,#FB       ;{{~{{~y{
       DB       #FE,#FB,#FB,#FE,#FD,#FB,#F1,#FD       ;~{{~}{q}
       DB       #FD,#EE,#3C,#FD,#95,#19,#FD,#7F       ;}n<}..}.
       DB       #FB,#0D,#81,#FE,#A5,#FE,#0F,#FE       ;{..~%~.~
       DB       #CE,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;N.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #C3,#FF,#FF,#3C,#3F,#FE,#CF,#C0       ;C..<?~O@
       DB       #FE,#31,#F8,#FE,#C0,#BE,#FF,#03       ;~1x~@>..
       DB       #3F,#FF,#FC,#3F,#FF,#FF,#C3,#FF       ;?.|?..C.
       DB       #FF,#FC,#FF,#FF,#FF,#FF,#FF,#FF       ;.|......
       DB       #FF,#FF,#FF,#00,#01,#FF,#02,#03       ;........
       DB       #FF,#04,#05,#FF,#06,#07,#FF,#00       ;........
       DB       #01,#FF,#02,#03,#FF,#04,#05,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#00,#FF       ;........
       DB       #FF,#01,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#00,#01,#FF,#02,#03,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#00,#01,#FF,#FF,#FF,#00       ;........
       DB       #FF,#FF,#01,#FF,#FF,#02,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#00       ;........
       DB       #FF,#01,#02,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#00,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#00,#01,#02,#FF,#FF,#FF,#00       ;........
       DB       #FF,#FF,#01,#02,#03,#04,#05,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#00,#FF,#FF,#FF,#00       ;........
       DB       #01,#02,#03,#04,#FF,#05,#06,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#00,#01,#FF,#FF,#06,#FF,#00       ;........
       DB       #01,#FF,#02,#03,#FF,#04,#05,#FF       ;........
       DB       #FF,#FF,#FF,#00,#FF,#FF,#01,#02       ;........
       DB       #FF,#03,#04,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#00,#01,#FF,#02,#03,#04       ;........
       DB       #FF,#FF,#FF,#00,#FF,#FF,#01,#FF       ;........
       DB       #FF,#02,#03,#FF,#FF,#FF,#FF,#00       ;........
       DB       #01,#FF,#02,#03,#06,#04,#05,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#00,#01       ;........
       DB       #02,#03,#04,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#00,#FF,#01,#02,#03       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#00       ;........
       DB       #FF,#FF,#01,#FF,#00,#01,#02,#03       ;........
       DB       #04,#05,#06,#00,#01,#02,#07,#08       ;........
       DB       #09,#0A,#00,#01,#02,#0B,#0C,#0D       ;........
       DB       #0E,#00,#01,#02,#0F,#10,#11,#12       ;........
       DB       #00,#13,#14,#15,#16,#17,#18,#00       ;........
       DB       #19,#1A,#1B,#1C,#1D,#1E,#00,#1F       ;........
       DB       #20,#21,#22,#23,#24,#CC,#25,#26       ; !"#$L%&
       DB       #27,#28,#29,#2A,#B0,#0C,#2B,#2C       ;'()*0.+,
       DB       #2D,#2E,#2F,#30,#F0,#F1,#0C,#31       ;-./0pq.1
       DB       #32,#33,#34,#35,#36,#F2,#F3,#24       ;23456rs$
       DB       #37,#38,#39,#3A,#24,#3B,#3C,#39       ;789:$;<9
       DB       #3A,#D8,#3D,#3E,#41,#3F,#40,#00       ;:X=>A?@.
       DB       #45,#46,#47,#48,#49,#4A,#0C,#4B       ;EFGHIJ.K
       DB       #4C,#4D,#4E,#4F,#50,#F8,#F9,#0C       ;LMNOPxy.
       DB       #51,#52,#53,#54,#55,#56,#F6,#F7       ;QRSTUVvw
       DB       #0C,#57,#58,#59,#5A,#5B,#5C,#F4       ;.WXYZ[\t
       DB       #F5,#3C,#5D,#5E,#5F,#48,#60,#61       ;u<]^_H`a
       DB       #62,#E4,#63,#64,#65,#66,#60,#68       ;bdcdef`h
       DB       #69,#6A,#84,#2A,#20,#33,#2B,#1B       ;ij.* 3+.
       DB       #2C,#32,#A8,#74,#75,#76,#72,#73       ;,2(tuvrs
       DB       #6C,#77,#78,#79,#7C,#7A,#7B,#00       ;lwxy|z{.
       DB       #7D,#7E,#7F,#80,#6F,#70,#00,#81       ;}~..op..
       DB       #82,#83,#84,#85,#86,#84,#87,#88       ;........
       DB       #8D,#89,#8A,#8B,#8C,#00,#8E,#8F       ;........
       DB       #90,#91,#92,#93,#00,#8E,#8F,#94       ;........
       DB       #95,#92,#96,#A8,#97,#99,#9A,#9B       ;...(....
       DB       #9C,#00,#9D,#9E,#9F,#A0,#A1,#A2       ;..... !"
       DB       #9C,#A3,#A4,#A5,#A6,#A7,#A8,#FA       ;.#$%&'(z
       DB       #84,#A9,#AA,#AF,#A5,#AB,#A7,#A8       ;.)*/%+'(
       DB       #60,#E8,#E9,#EA,#00,#B2,#B3,#B4       ;`hij.234
       DB       #B5,#B6,#B7,#24,#B8,#B9,#BA,#BB       ;567$89:;
       DB       #90,#BC,#BD,#F0,#BE,#BF,#90,#C0       ;.<=p>?.@
       DB       #C1,#F0,#C2,#C3,#24,#C4,#C5,#C6       ;ApBC$DEF
       DB       #C7,#00,#C8,#C9,#CA,#CB,#CC,#CD       ;G.HIJKLM
       DB       #00,#C8,#CE,#CA,#CF,#CC,#D0,#0C       ;.HNJOLP.
       DB       #C8,#D1,#CA,#D2,#CC,#D0,#FB,#FC       ;HQJRLP{|
       DB       #00,#D3,#D4,#D5,#D6,#D7,#D8,#00       ;.STUVWX.
       DB       #6B,#6C,#6D,#6E,#6F,#70,#A8,#97       ;klmnop(.
       DB       #99,#9A,#98,#B1,#60,#D9,#DA,#DB       ;...1`YZ[
       DB       #B4,#DC,#DD,#DE,#DF,#E0,#00,#67       ;4\]^_`.g
       DB       #71,#03,#04,#05,#06,#00,#EB,#EC       ;q.....kl
       DB       #ED,#EE,#05,#06,#00,#EF,#EC,#ED       ;mn...olm
       DB       #EE,#05,#06,#A8,#43,#44,#AE,#72       ;n..(CD.r
       DB       #73,#48,#E1,#E2,#E3,#24,#E4,#E5       ;sHabc$de
       DB       #E6,#E7,#00,#AC,#AD,#6D,#6E,#6F       ;fg.,-mno
       DB       #70,#3C,#02,#08,#0A,#3C,#02,#0C       ;p<...<..
       DB       #0E,#00,#2A,#30,#2B,#31,#2C,#32       ;..*0+1,2
       DB       #30,#69,#6A,#78,#6A,#90,#68,#69       ;0ijxj.hi
       DB       #54,#68,#30,#E9,#EA,#78,#EA,#90       ;Th0ijxj.
       DB       #E8,#E9,#54,#E8,#18,#26,#27,#18       ;hiTh.&'.
       DB       #26,#28,#A8,#2A,#2B,#03,#2C,#32       ;&((*+.,2
       DB       #C0,#2A,#2B,#2C,#00,#3C,#2A,#2B       ;@*+,.<*+
       DB       #2C,#48,#2D,#2F,#2E       ;,H-/.
L_AC9D       DB       #FC,#AA,#03,#AB,#0A,#AB,#11,#AB       ;|*.+.+.+
       DB       #18,#AB,#1F,#AB,#26,#AB,#2D,#AB       ;.+.+&+-+
       DB       #35,#AB,#3E,#AB,#47,#AB,#4C,#AB       ;5+>+G+L+
       DB       #51,#AB,#57,#AB,#5E,#AB,#67,#AB       ;Q+W+^+g+
       DB       #70,#AB,#79,#AB,#7D,#AB,#81,#AB       ;p+y+}+.+
       DB       #86,#AB,#8A,#AB,#92,#AB,#98,#AB       ;.+.+.+.+
       DB       #9F,#AB,#A6,#AB,#AD,#AB,#B5,#AB       ;.+&+-+5+
       DB       #BC,#AB,#C3,#AB,#C9,#AB,#D0,#AB       ;<+C+I+P+
       DB       #D8,#AB,#E0,#AB,#E4,#AB,#EB,#AB       ;X+`+d+k+
       DB       #F0,#AB,#F3,#AB,#F6,#AB,#F9,#AB       ;p+s+v+y+
       DB       #FC,#AB,#FC,#AB,#F9,#AB,#F6,#AB       ;|+|+y+v+
       DB       #F3,#AB,#F0,#AB,#EB,#AB,#01,#AC       ;s+p+k+.,
       DB       #08,#AC,#0F,#AC,#18,#AC,#FC,#AA       ;.,.,.,|*
       DB       #FC,#AA,#03,#AB,#0A,#AB,#11,#AB       ;|*.+.+.+
       DB       #35,#AB,#4C,#AB,#4C,#AB,#57,#AB       ;5+L+L+W+
       DB       #A6,#AB,#98,#AB,#51,#AB,#1F,#AC       ;&+.+Q+.,
       DB       #1F,#AC,#1F,#AC,#A6,#AB,#AD,#AB       ;.,.,&+-+
       DB       #92,#AB,#AD,#AB,#B5,#AB,#1F,#AC       ;.+-+5+.,
       DB       #D0,#AB,#D8,#AB,#18,#AC,#1F,#AC       ;P+X+.,.,
       DB       #26,#AC,#2C,#AC,#2C,#AC,#30,#AC       ;&,,,,,0,
       DB       #11,#AB,#1F,#AC,#36,#AC,#3D,#AC       ;.+.,6,=,
       DB       #44,#AC,#4B,#AC,#51,#AC,#55,#AC       ;D,K,Q,U,
       DB       #5A,#AC,#E0,#AB,#55,#AC,#61,#AC       ;Z,`+U,a,
       DB       #65,#AC,#FC,#AA,#5E,#AB,#69,#AC       ;e,|*^+i,
       DB       #51,#AB,#03,#AB,#0A,#AB,#11,#AB       ;Q+.+.+.+
       DB       #86,#AB,#70,#AC,#73,#AC,#75,#AC       ;.+p,s,u,
       DB       #78,#AC,#E0,#AB,#7A,#AC,#7D,#AC       ;x,`+z,},
       DB       #7F,#AC,#82,#AC,#84,#AC,#87,#AC       ;.,.,.,.,
       DB       #8A,#AC,#90,#AC,#95,#AC,#99,#AC       ;.,.,.,.,
L_AD85       DB       #D5,#AD,#EA,#AD,#EF,#AD,#F4,#AD       ;U-j-o-t-
       DB       #F9,#AD,#FE,#AD,#04,#AE,#06,#AE       ;y-~-....
       DB       #0E,#AE,#17,#AE,#1D,#AE,#20,#AE       ;...... .
       DB       #26,#AE,#2B,#AE,#2F,#AE,#35,#AE       ;&.+./.5.
       DB       #39,#AE,#3D,#AE,#42,#AE,#47,#AE       ;9.=.B.G.
       DB       #54,#AE,#56,#AE,#58,#AE,#5A,#AE       ;T.V.X.Z.
       DB       #5C,#AE,#5E,#AE,#63,#AE,#67,#AE       ;\.^.c.g.
       DB       #74,#AE,#83,#AE,#8B,#AE,#8E,#AE       ;t.......
       DB       #96,#AE,#9E,#AE,#A6,#AE,#AB,#AE       ;....&.+.
       DB       #B7,#AE,#C2,#AE,#C4,#AE,#D1,#AE       ;7.B.D.Q.
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#52,#53,#54       ;.....RST
       DB       #53,#54,#53,#54,#FD,#01,#02,#03       ;STST}...
       DB       #33,#FD,#37,#36,#35,#34,#FD,#04       ;3}7654}.
       DB       #05,#06,#07,#FD,#08,#09,#38,#00       ;...}..8.
       DB       #FD,#0A,#0B,#0C,#60,#39,#FD,#3A       ;}...`9}:
       DB       #FE,#0E,#0F,#10,#19,#1A,#45,#19       ;~.....E.
       DB       #FD,#11,#11,#11,#12,#12,#12,#13       ;}.......
       DB       #14,#FE,#55,#16,#17,#3D,#44,#FD       ;.~U..=D}
       DB       #3F,#18,#FE,#41,#42,#43,#45,#3C       ;?.~ABCE<
       DB       #FD,#1B,#1C,#46,#00,#FD,#1D,#1E       ;}..F.}..
       DB       #00,#FE,#58,#1F,#20,#49,#48,#FD       ;.~X. IH}
       DB       #32,#22,#4A,#FD,#50,#4B,#51,#FE       ;2"J}PKQ~
       DB       #23,#24,#25,#26,#FD,#29,#2B,#2C       ;#$%&})+,
       DB       #2D,#FD,#00,#2F,#2F,#30,#31,#31       ;-}.//011
       DB       #31,#31,#31,#30,#2F,#2F,#FE,#3B       ;1110//~;
       DB       #FD,#3E,#FD,#40,#FD,#0D,#FD,#28       ;}>}@}.}(
       DB       #FD,#4C,#4D,#4E,#4F,#FE,#15,#15       ;}LMNO~..
       DB       #5F,#FE,#50,#0D,#56,#56,#56,#56       ;_~P.VVVV
       DB       #56,#57,#5A,#5A,#21,#59,#FE,#5B       ;VWZZ!Y~[
       DB       #5B,#5B,#5B,#5C,#5D,#01,#02,#03       ;[[[\]...
       DB       #33,#01,#02,#03,#FF,#00,#64,#64       ;3.....dd
       DB       #65,#65,#66,#66,#66,#FE,#6E,#6F       ;eefff~no
       DB       #FD,#64,#64,#67,#67,#68,#68,#68       ;}ddgghhh
       DB       #FE,#69,#69,#6A,#6A,#6B,#6B,#6B       ;~iijjkkk
       DB       #FE,#69,#69,#6C,#6C,#6D,#6D,#6D       ;~iillmmm
       DB       #FE,#00,#5E,#0F,#10,#FE,#34,#61       ;~.^..~4a
       DB       #62,#63,#34,#61,#62,#63,#34,#61       ;bc4abc4a
       DB       #FF,#00,#0E,#0F,#10,#00,#34,#61       ;......4a
       DB       #1B,#1C,#46,#00,#FE,#00,#FE,#5F       ;..F.~.~_
       DB       #5F,#70,#70,#70,#70,#71,#71,#71       ;_ppppqqq
       DB       #71,#72,#73,#FE,#2F,#FE       ;qrs~/~
L_AED3       DB       #00,#00,#00,#81,#80,#81,#80,#81       ;........
       DB       #C1,#81,#80,#81,#80,#80,#81,#80       ;A.......
       DB       #80,#80,#80,#C0,#80,#80,#80,#80       ;...@....
       DB       #80,#80,#C0,#C1,#C0,#C1,#81,#C1       ;..@A@A.A
       DB       #C1,#C1,#C0,#C0,#C0,#C0,#C0,#C0       ;AA@@@@@@
L_AEFB       DB       #6B,#AF,#6B,#AF,#6B,#AF,#6B,#AF       ;k/k/k/k/
       DB       #6B,#AF,#74,#AF,#7D,#AF,#86,#AF       ;k/t/}/./
       DB       #8F,#AF,#86,#AF,#98,#AF,#6B,#AF       ;./././k/
       DB       #6B,#AF,#8F,#AF,#6B,#AF,#6B,#AF       ;k/./k/k/
       DB       #6B,#AF,#A1,#AF,#8F,#AF,#8F,#AF       ;k/!/././
       DB       #8F,#AF,#8F,#AF,#6B,#AF,#AA,#AF       ;././k/;*/
       DB       #B3,#AF,#6B,#AF,#8F,#AF,#8F,#AF       ;3/k/././
L_AF33       DB       #BC,#AF,#BC,#AF,#BC,#AF,#BC,#AF       ;</</</</
       DB       #BC,#AF,#C5,#AF,#C5,#AF,#BC,#AF       ;</E/E/</
       DB       #BC,#AF,#BC,#AF,#BC,#AF,#BC,#AF       ;</</</</
       DB       #BC,#AF,#BC,#AF,#BC,#AF,#BC,#AF       ;</</</</
       DB       #BC,#AF,#A1,#AF,#BC,#AF,#BC,#AF       ;</!/</</
       DB       #BC,#AF,#BC,#AF,#BC,#AF,#CE,#AF       ;</</</N/
       DB       #BC,#AF,#BC,#AF,#BC,#AF,#BC,#AF       ;</</</</
       DB       #00,#01,#02,#17,#04,#11,#0A,#12       ;........
       DB       #10,#14,#01,#02,#06,#04,#11,#0A       ;........
       DB       #12,#10,#14,#14,#14,#06,#14,#11       ;........
       DB       #14,#12,#14,#00,#01,#02,#17,#04       ;........
       DB       #11,#0A,#12,#10,#00,#01,#02,#06       ;........
       DB       #04,#11,#0A,#12,#10,#16,#01,#02       ;........
       DB       #17,#04,#11,#0A,#12,#10,#18,#18       ;........
       DB       #18,#06,#18,#18,#18,#18,#18,#06       ;........
       DB       #06,#06,#06,#06,#06,#06,#06,#06       ;........
       DB       #00,#01,#02,#00,#04,#00,#0A,#12       ;........
       DB       #10,#00,#09,#07,#17,#0B,#0C,#0F       ;........
       DB       #0E,#03,#14,#14,#14,#05,#14,#14       ;........
       DB       #14,#14,#14,#05,#05,#05,#05,#05       ;........
       DB       #05,#05,#05,#05       ;....
L_AFD7       DB       #05,#FC,#AF,#07,#6F,#B0,#0C,#E4       ;.|/.o0.d
       DB       #B0,#17,#5F,#B1,#1A,#D0,#B1,#1C       ;0._1.P1.
       DB       #45,#B2,#20,#AC,#B2,#22,#FF,#B2       ;E2 ,2".2
       DB       #24,#3C,#B3,#25,#A7,#B3,#26,#10       ;$<3%'3&.
       DB       #B4,#43,#79,#B4,#80,#00,#13,#01       ;4Cy4....
       DB       #13,#02,#13,#03,#13,#04,#13,#05       ;........
       DB       #0E,#06,#13,#07,#06,#08,#14,#0A       ;........
       DB       #13,#0B,#13,#0D,#13,#0E,#13,#0F       ;........
       DB       #15,#10,#13,#15,#13,#16,#13,#17       ;........
       DB       #13,#17,#10,#18,#13,#19,#13,#1B       ;........
       DB       #15,#1F,#13,#22,#15,#28,#13,#32       ;...".(.2
       DB       #15,#33,#15,#34,#14,#35,#14,#36       ;.3.4.5.6
       DB       #14,#37,#14,#39,#13,#3A,#13,#3B       ;.7.9.:.;
       DB       #14,#3C,#14,#3D,#14,#3E,#15,#3F       ;.<.=.>.?
       DB       #13,#40,#13,#41,#13,#42,#13,#44       ;.@.A.B.D
       DB       #13,#45,#13,#46,#15,#47,#13,#48       ;.E.F.G.H
       DB       #13,#49,#13,#4A,#15,#4B,#13,#50       ;.I.J.K.P
       DB       #13,#51,#13,#52,#13,#53,#13,#54       ;.Q.R.S.T
       DB       #13,#55,#13,#58,#13,#60,#13,#FF       ;.U.X.`..
       DB       #00,#16,#01,#16,#02,#16,#03,#16       ;........
       DB       #04,#16,#05,#0E,#06,#16,#07,#06       ;........
       DB       #08,#17,#0A,#16,#0B,#16,#0D,#16       ;........
       DB       #0E,#16,#0F,#18,#10,#16,#15,#16       ;........
       DB       #16,#16,#17,#16,#17,#10,#18,#16       ;........
       DB       #19,#16,#1A,#18,#1B,#18,#1F,#16       ;........
       DB       #22,#18,#28,#16,#32,#18,#33,#18       ;".(.2.3.
       DB       #34,#17,#35,#17,#36,#17,#37,#17       ;4.5.6.7.
       DB       #39,#16,#3A,#16,#3B,#17,#3C,#17       ;9.:.;.<.
       DB       #3D,#17,#3E,#18,#3F,#16,#40,#16       ;=.>.?.@.
       DB       #41,#16,#42,#16,#44,#16,#45,#16       ;A.B.D.E.
       DB       #46,#18,#47,#16,#48,#16,#49,#16       ;F.G.H.I.
       DB       #4A,#18,#4B,#16,#50,#18,#51,#16       ;J.K.P.Q.
       DB       #52,#16,#53,#16,#54,#16,#55,#18       ;R.S.T.U.
       DB       #58,#18,#60,#18,#FF,#00,#19,#01       ;X.`.....
       DB       #19,#02,#19,#03,#19,#04,#19,#05       ;........
       DB       #19,#06,#19,#07,#19,#08,#1A,#0A       ;........
       DB       #1A,#0B,#1A,#0C,#06,#0D,#19,#0E       ;........
       DB       #19,#0F,#19,#10,#19,#15,#1A,#16       ;........
       DB       #1A,#17,#1A,#18,#1B,#19,#1B,#1A       ;........
       DB       #1B,#1B,#1C,#1F,#19,#20,#1B,#22       ;..... ."
       DB       #1B,#23,#1A,#28,#08,#29,#1A,#32       ;.#.(.).2
       DB       #19,#33,#19,#34,#19,#35,#19,#36       ;.3.4.5.6
       DB       #19,#37,#19,#39,#06,#3A,#1A,#3B       ;.7.9.:.;
       DB       #19,#3C,#1A,#3D,#1A,#3E,#1A,#3F       ;.<.=.>.?
       DB       #1A,#40,#1A,#41,#1A,#42,#19,#43       ;.@.A.B.C
       DB       #1B,#44,#1B,#45,#1B,#46,#1C,#47       ;.D.E.F.G
       DB       #1A,#48,#19,#49,#19,#4A,#19,#4B       ;.H.I.J.K
       DB       #1A,#50,#19,#51,#19,#52,#19,#53       ;.P.Q.R.S
       DB       #19,#54,#19,#55,#19,#58,#19,#FF       ;.T.U.X..
       DB       #00,#1D,#01,#1D,#02,#1D,#03,#1D       ;........
       DB       #04,#1E,#06,#1D,#08,#1F,#0A,#1F       ;........
       DB       #0B,#1D,#0D,#1D,#0E,#1D,#0F,#1D       ;........
       DB       #10,#1D,#15,#1E,#16,#1D,#17,#06       ;........
       DB       #18,#0E,#19,#1D,#1B,#1F,#1C,#0F       ;........
       DB       #1F,#1F,#22,#1F,#23,#1F,#29,#1D       ;..".#.).
       DB       #32,#1D,#33,#1D,#34,#1D,#35,#1D       ;2.3.4.5.
       DB       #36,#1D,#37,#1D,#39,#1D,#3A,#1D       ;6.7.9.:.
       DB       #3B,#1D,#3C,#1D,#3D,#06,#3E,#1D       ;;.<.=.>.
       DB       #3F,#1D,#40,#1D,#41,#1D,#42,#1D       ;?.@.A.B.
       DB       #44,#1D,#45,#1D,#46,#1F,#47,#1D       ;D.E.F.G.
       DB       #48,#1D,#49,#1D,#4A,#1D,#4B,#1D       ;H.I.J.K.
       DB       #50,#1D,#51,#1D,#52,#1D,#53,#1D       ;P.Q.R.S.
       DB       #54,#1D,#55,#1D,#58,#1D,#60,#1D       ;T.U.X.`.
       DB       #FF,#00,#04,#01,#04,#02,#04,#03       ;........
       DB       #04,#04,#05,#05,#05,#06,#05,#08       ;........
       DB       #00,#09,#25,#0D,#24,#0E,#25,#0F       ;..%.$.%.
       DB       #24,#10,#24,#15,#24,#16,#25,#17       ;$.$.$.%.
       DB       #25,#18,#24,#19,#24,#1A,#06,#1B       ;%.$.$...
       DB       #26,#1B,#0D,#1C,#26,#1C,#0D,#1F       ;&...&...
       DB       #24,#31,#25,#32,#04,#33,#04,#34       ;$1%2.3.4
       DB       #04,#35,#04,#36,#04,#37,#04,#3B       ;.5.6.7.;
       DB       #24,#3C,#25,#3D,#25,#3F,#05,#3F       ;$<%=%?.?
       DB       #0B,#40,#05,#40,#0B,#41,#05,#41       ;.@.@.A.A
       DB       #0B,#42,#05,#42,#0B,#43,#06,#44       ;.B.B.C.D
       DB       #05,#44,#0B,#46,#05,#47,#05,#47       ;.D.F.G.G
       DB       #0B,#48,#04,#4B,#05,#4B,#0B,#50       ;.H.K.K.P
       DB       #05,#51,#04,#52,#04,#53,#04,#54       ;.Q.R.S.T
       DB       #04,#55,#05,#58,#05,#FF,#00,#0A       ;.U.X....
       DB       #01,#0A,#02,#0A,#03,#0A,#04,#0A       ;........
       DB       #05,#0A,#06,#0A,#07,#0A,#0A,#0A       ;........
       DB       #0B,#0A,#0C,#0A,#0D,#0C,#0E,#0A       ;........
       DB       #0F,#0A,#10,#0A,#15,#0A,#17,#0A       ;........
       DB       #19,#0A,#1A,#0A,#1F,#0A,#22,#0C       ;......".
       DB       #23,#0C,#32,#0A,#33,#0A,#34,#0A       ;#.2.3.4.
       DB       #35,#0A,#36,#0A,#37,#0A,#39,#0A       ;5.6.7.9.
       DB       #3A,#0A,#3B,#0C,#3C,#0A,#3D,#0A       ;:.;.<.=.
       DB       #3E,#0A,#3F,#0A,#40,#0A,#41,#0A       ;>.?.@.A.
       DB       #42,#0A,#44,#0A,#47,#0A,#48,#0A       ;B.D.G.H.
       DB       #4A,#0A,#4B,#0A,#50,#0A,#51,#0A       ;J.K.P.Q.
       DB       #52,#0A,#53,#0A,#54,#0A,#55,#0A       ;R.S.T.U.
       DB       #58,#0A,#60,#0A,#FF,#00,#20,#01       ;X.`... .
       DB       #20,#02,#20,#03,#20,#04,#21,#05       ; . . .!.
       DB       #21,#06,#21,#07,#21,#08,#22,#09       ;!.!.!.".
       DB       #20,#0D,#21,#0E,#20,#0F,#22,#10       ; .!. .".
       DB       #20,#15,#21,#15,#0D,#16,#21,#17       ; .!...!.
       DB       #21,#18,#20,#19,#21,#1B,#23,#1C       ;!. .!.#.
       DB       #23,#1F,#20,#20,#06,#22,#0F,#32       ;#.  .".2
       DB       #20,#33,#20,#34,#20,#35,#20,#36       ; 3 4 5 6
       DB       #20,#37,#20,#43,#20,#4A,#20,#4B       ; 7 C J K
       DB       #10,#50,#20,#51,#10,#52,#20,#53       ;.P Q.R S
       DB       #20,#54,#20,#55,#21,#58,#20,#FF       ; T U!X .
       DB       #00,#03,#01,#03,#02,#03,#03,#03       ;........
       DB       #0E,#03,#0F,#03,#10,#03,#15,#03       ;........
       DB       #18,#03,#19,#03,#1A,#03,#1F,#03       ;........
       DB       #20,#03,#32,#03,#33,#03,#34,#03       ; .2.3.4.
       DB       #35,#03,#36,#03,#37,#03,#42,#03       ;5.6.7.B.
       DB       #43,#03,#44,#03,#48,#03,#49,#03       ;C.D.H.I.
       DB       #4A,#03,#50,#03,#52,#03,#53,#03       ;J.P.R.S.
       DB       #54,#03,#58,#03,#FF,#00,#11,#01       ;T.X.....
       DB       #11,#02,#11,#03,#11,#04,#11,#05       ;........
       DB       #11,#06,#11,#07,#11,#0A,#11,#0B       ;........
       DB       #11,#0C,#11,#0D,#11,#0E,#11,#0F       ;........
       DB       #11,#10,#11,#15,#11,#16,#11,#17       ;........
       DB       #11,#18,#11,#19,#11,#1A,#11,#1C       ;........
       DB       #12,#1F,#11,#20,#11,#22,#11,#32       ;... .".2
       DB       #11,#33,#11,#34,#11,#35,#11,#36       ;.3.4.5.6
       DB       #11,#37,#11,#39,#11,#3A,#11,#3B       ;.7.9.:.;
       DB       #11,#3C,#11,#3D,#11,#41,#11,#42       ;.<.=.A.B
       DB       #11,#43,#11,#44,#11,#45,#11,#48       ;.C.D.E.H
       DB       #11,#49,#11,#4A,#11,#4B,#11,#50       ;.I.J.K.P
       DB       #11,#51,#11,#52,#11,#53,#11,#54       ;.Q.R.S.T
       DB       #11,#55,#11,#58,#11,#60,#11,#FF       ;.U.X.`..
       DB       #00,#12,#01,#12,#02,#12,#03,#12       ;........
       DB       #04,#12,#05,#12,#06,#12,#07,#12       ;........
       DB       #0A,#12,#0B,#12,#0C,#12,#0D,#12       ;........
       DB       #0E,#12,#0F,#12,#10,#12,#15,#12       ;........
       DB       #16,#12,#17,#12,#18,#12,#19,#12       ;........
       DB       #1A,#12,#1C,#12,#1F,#12,#20,#12       ;...... .
       DB       #32,#12,#33,#12,#34,#12,#35,#12       ;2.3.4.5.
       DB       #36,#12,#37,#12,#39,#12,#3A,#12       ;6.7.9.:.
       DB       #3B,#12,#3C,#12,#3D,#12,#41,#12       ;;.<.=.A.
       DB       #42,#12,#43,#12,#44,#12,#45,#12       ;B.C.D.E.
       DB       #48,#12,#49,#12,#4A,#12,#4B,#12       ;H.I.J.K.
       DB       #50,#12,#51,#12,#52,#12,#53,#12       ;P.Q.R.S.
       DB       #54,#12,#55,#12,#58,#12,#60,#12       ;T.U.X.`.
       DB       #FF,#00,#11,#01,#11,#02,#11,#03       ;........
       DB       #11,#04,#11,#05,#11,#06,#11,#07       ;........
       DB       #11,#0A,#11,#0B,#11,#0C,#11,#0D       ;........
       DB       #11,#0E,#11,#0F,#11,#10,#11,#15       ;........
       DB       #11,#16,#11,#17,#11,#18,#11,#19       ;........
       DB       #11,#1A,#11,#1C,#12,#1F,#11,#20       ;....... 
       DB       #11,#32,#11,#33,#11,#34,#11,#35       ;.2.3.4.5
       DB       #11,#36,#11,#37,#11,#39,#11,#3A       ;.6.7.9.:
       DB       #11,#3B,#11,#3C,#11,#3D,#11,#41       ;.;.<.=.A
       DB       #11,#42,#11,#43,#11,#44,#11,#45       ;.B.C.D.E
       DB       #11,#48,#11,#49,#11,#4A,#11,#4B       ;.H.I.J.K
       DB       #11,#50,#11,#51,#11,#52,#11,#53       ;.P.Q.R.S
       DB       #11,#54,#11,#55,#11,#58,#11,#60       ;.T.U.X.`
       DB       #11,#FF,#00,#25,#01,#25,#02,#25       ;...%.%.%
       DB       #03,#25,#04,#25,#05,#26,#06,#26       ;.%.%.&.&
       DB       #07,#25,#08,#24,#09,#25,#0D,#25       ;.%.$.%.%
       DB       #0E,#25,#0F,#24,#10,#24,#15,#24       ;.%.$.$.$
       DB       #16,#25,#17,#25,#18,#24,#19,#24       ;.%.%.$.$
       DB       #1B,#02,#1B,#0D,#1C,#02,#1C,#0D       ;........
       DB       #1F,#24,#27,#25,#28,#25,#31,#25       ;.$'%(%1%
       DB       #32,#25,#33,#25,#34,#25,#35,#25       ;2%3%4%5%
       DB       #36,#25,#37,#25,#3B,#24,#3C,#25       ;6%7%;$<%
       DB       #3D,#25,#3F,#25,#40,#25,#41,#25       ;=%?%@%A%
       DB       #42,#25,#43,#06,#44,#25,#46,#26       ;B%C.D%F&
       DB       #47,#25,#48,#25,#4B,#25,#50,#25       ;G%H%K%P%
       DB       #51,#24,#52,#25,#53,#25,#54,#25       ;Q$R%S%T%
       DB       #55,#26,#58,#25,#FF       ;U&X%.
L_B4E4       DB       #1B,#0D,#32,#1A,#0D,#32,#15,#0D       ;..2..2..
       DB       #32,#00,#19,#22,#1A,#08,#40,#15       ;2.."..@.
       DB       #08,#40,#1B,#FF,#60,#1B,#19,#22       ;.@..`.."
       DB       #1A,#19,#22,#15,#19,#22,#00,#19       ;..".."..
       DB       #12,#BF,#FF,#32,#15,#19,#12,#BF       ;.?.2...?
       DB       #FF,#50,#1A,#FF,#60,#6F,#0D,#32       ;.P..`o.2
       DB       #6F,#FF,#50,#00,#19,#20,#15,#19       ;o.P.. ..
       DB       #20,#00,#19,#32,#1A,#19,#32,#15       ; ..2..2.
       DB       #19,#32,#00,#19,#32,#1A,#19,#32       ;.2..2..2
       DB       #15,#19,#32,#1A,#0D,#32,#15,#0D       ;..2..2..
       DB       #32,#1B,#0D,#32,#00,#0D,#32,#15       ;2..2..2.
       DB       #0D,#32,#00,#0D,#32,#1A,#0D,#32       ;.2..2..2
       DB       #1A,#19,#32,#15,#19,#32,#1B,#19       ;..2..2..
       DB       #32,#00,#19,#32,#1B,#0D,#32,#1A       ;2..2..2.
       DB       #0D,#32,#15,#0D,#32       ;.2..2
L_B559       DB       #01,#00       ;..
L_B55B       DB       #00       ;.
L_B55C       DB       #04,#D5,#AD       ;.U-
L_B55F       DB       #01       ;.
L_B560       DB       #06       ;.
L_B561       DB       #00       ;.
L_B562       DB       #02,#00       ;..
L_B564       DB       #01       ;.
L_B565       DB       #11,#D5,#AD       ;.U-
L_B568       DB       #01       ;.
L_B569       DB       #06       ;.
L_B56A       DB       #00       ;.
L_B56B       DB       #00,#00       ;..
L_B56D       DB       #00       ;.
L_B56E       DB       #00,#EA,#AD,#01,#00,#00       ;.j-...
L_B574       DB       #00,#00       ;..
L_B576       DB       #00       ;.
L_B577       DB       #80,#68,#A0,#75       ;.h u
L_B57B       DB       #80,#68       ;.h
L_B57D       DB       #16,#B6       ;.6
L_B57F       DB       #16,#B6,#83,#B5,#01,#62,#03,#60       ;.6.5.b.`
       DB       #01,#7C,#02,#7D,#01,#68,#0E,#6F       ;.|.}.h.o
       DB       #04,#6C,#01,#44,#01,#64,#FF,#01       ;.l.D.d..
       DB       #62,#03,#60,#01,#64,#02,#7C,#0E       ;b.`.d.|.
       DB       #6F,#03,#6C,#01,#64,#01,#6C,#01       ;o.l.d.l.
       DB       #44,#01,#64,#FF,#04,#60,#01,#6C       ;D.d..`.l
       DB       #0F,#7C,#05,#6C,#02,#60,#01,#44       ;.|.l.`.D
       DB       #FF,#01,#60,#10,#60,#01,#6C,#05       ;..`.`.l.
       DB       #60,#01,#6C,#02,#60,#02,#44,#FF       ;`.l.`.D.
       DB       #01,#42,#19,#60,#02,#44,#FF,#01       ;.B.`.D..
       DB       #42,#01,#60,#01,#70,#01,#60,#03       ;B.`.p.`.
       DB       #70,#13,#60,#02,#44,#FF,#01,#42       ;p.`.D..B
       DB       #05,#70,#02,#60,#02,#70,#01,#60       ;.p.`.p.`
       DB       #02,#70,#03,#60,#01,#70,#01,#60       ;.p.`.p.`
       DB       #02,#70,#02,#60,#04,#70,#02,#44       ;.p.`.p.D
       DB       #FF,#1C,#70,#FF,#1C,#70,#FF,#1C       ;..p..p..
       DB       #70,#FF,#1C,#70,#FF,#1C,#70,#FF       ;p..p..p.
       DB       #1C,#70,#FF,#1C,#70,#FF,#1C,#70       ;.p..p..p
       DB       #FF,#1C,#70,#FF,#16,#70,#FF       ;..p..p.
L_B616       DB       #01,#52,#1A,#56,#01,#54,#FF,#01       ;.R.V.T..
       DB       #52,#1A,#56,#01,#54,#FF,#03,#51       ;R.V.T..Q
       DB       #04,#56,#01,#71,#02,#59,#01,#71       ;.V.q.Y.q
       DB       #0E,#56,#03,#51,#FF,#01,#59,#03       ;.V.Q..Y.
       DB       #51,#03,#56,#01,#71,#02,#59,#01       ;Q.V.q.Y.
       DB       #71,#0D,#56,#03,#51,#01,#59,#FF       ;q.V.Q.Y.
       DB       #01,#5A,#02,#59,#02,#51,#02,#56       ;.Z.Y.Q.V
       DB       #01,#71,#03,#59,#01,#71,#0B,#72       ;.q.Y.q.r
       DB       #02,#51,#02,#59,#01,#5C,#FF,#01       ;.Q.Y.\..
       DB       #5A,#04,#59,#02,#51,#04,#59,#03       ;Z.Y.Q.Y.
       DB       #71,#02,#7E,#05,#71,#01,#59,#01       ;q.~.q.Y.
       DB       #51,#04,#59,#01,#5C,#FF,#01,#5A       ;Q.Y.\..Z
       DB       #03,#58,#17,#59,#01,#5C,#FF,#1C       ;.X.Y.\..
       DB       #58,#FF,#1C,#58,#FF,#1C,#58,#FF       ;X..X..X.
       DB       #1C,#58,#FF,#1C,#58,#FF,#1C,#58       ;.X..X..X
       DB       #FF,#1C,#58,#FF,#1C,#58,#FF,#1C       ;..X..X..
       DB       #58,#FF,#16,#58,#FF       ;X..X.
L_B69B       DB       #05,#05,#07,#07,#06,#07,#0C,#06       ;........
       DB       #09,#17,#06,#07,#1A,#07,#05,#1C       ;........
       DB       #05,#07,#20,#07,#04,#22,#05,#04       ;.. .."..
       DB       #43,#07,#05,#80       ;C...
L_B6B7       DB       #05,#32,#00,#07,#32,#00,#0C,#32       ;.2..2..2
       DB       #00,#17,#C8,#00,#1A,#F4,#01,#1C       ;..H..t..
       DB       #64,#00,#20,#64,#00,#22,#C8,#00       ;d. d."H.
       DB       #43,#C8,#00,#80       ;CH..
L_B6D3       DB       #00       ;.
L_B6D4       DB       #00,#00       ;..
RedAttrAddr dw redattr_killable2b ;DB       #00,#00       ;..
L_B6D8       DB       #FF       ;.
L_B6D9       DB       #00       ;.
L_B6DA       DB       #00       ;.
L_B6DB       DB       #F3,#B6       ;s6
L_B6DD       DB       #A9,#B7       ;)7
L_B6DF       DB       #00,#00       ;..
L_B6E1       DB       #00,#01       ;..
L_B6E3       DB       #73,#B8,#00,#00       ;s8..
L_B6E7       DB       #0A,#5E       ;.^
L_B6E9       DB       #00,#06       ;..
L_B6EB       DB       #00,#01,#02,#06,#0A,#1A,#2A       ;......*
L_B6F2       DB       #00       ;.
L_B6F3       DB       #01,#02,#04,#05,#01,#02,#04,#05       ;........
       DB       #01,#02,#04,#05,#01,#01,#02,#02       ;........
       DB       #02,#FF       ;..
L_B705       DB       #10,#11,#13,#14,#10,#11,#13,#14       ;........
       DB       #10,#11,#13,#14,#10,#10,#11,#11       ;........
       DB       #11,#FF,#12,#16,#12,#16,#12,#16       ;........
       DB       #12,#16,#12,#16,#12,#16,#12,#16       ;........
       DB       #12,#FF,#00,#00,#02,#02,#03,#03       ;........
       DB       #04,#04,#05,#05,#05,#05,#06,#06       ;........
       DB       #06,#06,#06,#06,#06,#06,#07,#07       ;........
       DB       #07,#07,#07,#07,#07,#07,#07,#07       ;........
       DB       #07,#07,#07,#07,#01,#01,#02,#03       ;........
       DB       #03,#04,#04,#04,#05,#05,#05,#05       ;........
       DB       #05,#06,#06,#06,#06,#06,#06,#06       ;........
       DB       #06,#07,#07,#07,#07,#07,#07,#07       ;........
       DB       #07,#07,#07,#07,#00,#00,#01,#01       ;........
       DB       #02,#02,#02,#03,#03,#03,#03,#04       ;........
       DB       #04,#04,#04,#05,#05,#05,#05,#05       ;........
       DB       #06,#06,#06,#06,#06,#07,#07,#07       ;........
       DB       #07,#07,#07,#07,#00,#00,#00,#00       ;........
       DB       #00,#01,#01,#01,#01,#01,#02,#02       ;........
       DB       #02,#02,#03,#03,#03,#03,#04,#04       ;........
       DB       #04,#04,#05,#05,#05,#05,#06,#06       ;........
       DB       #06,#07,#07,#07       ;....
L_B7A9       DB       #01,#06,#01,#03,#00,#00,#02,#02       ;........
       DB       #02,#04,#02,#06,#02,#08,#02,#0A       ;........
       DB       #02,#0C,#02,#0E,#01,#04,#01,#02       ;........
       DB       #00,#00,#02,#02,#02,#04,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#01,#01,#01,#01,#01       ;........
       DB       #02,#02,#02,#02,#02,#03,#03,#03       ;........
       DB       #03,#04,#04,#04,#04,#05,#05,#05       ;........
       DB       #06,#06,#07,#07       ;....
L_B7ED       DB       #01,#06,#01,#03,#00,#00,#02,#06       ;........
       DB       #02,#03,#00,#00,#01,#03,#00,#00       ;........
       DB       #02,#03,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#01,#01,#01       ;........
       DB       #01,#01,#01,#01,#01,#02,#02,#02       ;........
       DB       #02,#02,#03,#03,#03,#04,#04,#05       ;........
       DB       #05,#06,#02,#08,#02,#08,#02,#0A       ;........
       DB       #02,#0A,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #01,#01,#01,#01,#01,#01,#01,#01       ;........
       DB       #02,#02,#02,#02,#03,#03,#04,#04       ;........
       DB       #05,#05,#00,#00,#00,#01,#01,#01       ;........
       DB       #02,#02,#02,#03,#03,#03,#03,#04       ;........
       DB       #04,#04,#04,#05,#05,#05,#05,#06       ;........
       DB       #06,#06,#06,#06,#06,#07       ;......
L_B873       DB       #07,#07,#07,#07,#08,#09,#0A,#0B       ;........
       DB       #0C,#0D,#17,#1F,#0C,#25,#0E,#FF       ;.....%..
       DB       #0F,#FF,#FF,#FF,#FF,#17,#15,#15       ;........
       DB       #18,#15,#1A,#1C,#1C,#1E,#1D,#1F       ;........
       DB       #1F,#FF,#22,#FF,#FF,#FF,#FF,#FF       ;..".....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#23       ;.......#
       DB       #23,#23,#21,#07,#07,#07,#07,#07       ;##!.....
       DB       #0C,#1F,#1F,#25,#15,#15,#17,#17       ;...%....
       DB       #17,#17,#15,#1A,#15,#1A,#1C,#15       ;........
       DB       #1F,#1F,#21,#17,#1E,#24,#24,#19       ;..!..$$.
       DB       #07,#17,#23,#23,#23,#15,#FF,#29       ;..###..)
       DB       #FF,#FF,#29,#FF,#FF,#07,#0E,#FF       ;..).....
       DB       #0C,#07,#07,#07,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF       ;......
L_B8E1       DB       #94,#94,#94,#94,#55,#55,#55,#55       ;....UUUU
       DB       #4A,#41,#67,#69,#67,#5B,#0E,#00       ;JAgig[..
       DB       #CD,#00,#00,#00,#00,#55,#56,#55       ;M....UVU
       DB       #55,#53,#95,#14,#14,#15,#D5,#95       ;US....U.
       DB       #95,#00,#D5,#00,#00,#00,#00,#00       ;..U.....
       DB       #00,#00,#00,#00,#00,#00,#00,#56       ;.......V
       DB       #56,#56,#55,#94,#94,#94,#94,#94       ;VVU.....
       DB       #4A,#69,#69,#5B,#53,#55,#55,#55       ;Jii[SUUU
       DB       #55,#55,#53,#95,#56,#95,#14,#55       ;UUS.V..U
       DB       #95,#95,#55,#55,#15,#3F,#3F,#6B       ;..UU.??k
       DB       #94,#55,#55,#55,#55,#56,#00,#3A       ;.UUUUV.:
       DB       #00,#00,#3A,#00,#00,#94,#0E,#00       ;..:.....
       DB       #67,#94,#94,#94       ;g...
L_B945       DB       #00,#00       ;..
L_B947       DB       #00,#00       ;..
L_B949       DB       #22,#25,#26,#12,#1A       ;"%&..
L_B94E       DB       #18       ;.
L_B94F       DB       #20       ; 
L_B950       DB       #23,#1B,#13,#03,#0B       ;#....
L_B955       DB       #23,#1B,#13,#03,#0B       ;#....
L_B95A       DB       #04,#0C,#14,#24,#1C       ;...$.
L_B95F       DB       #00       ;.
L_B960       DB       #00       ;.
L_B961       DB       #00       ;.
L_B962       DB       #00,#01,#02,#00,#03,#05,#07,#00       ;........
       DB       #04,#06,#08,#00,#00,#00,#00,#00       ;........
L_B972       DB       #00       ;.
L_B973       DB       #00       ;.
L_B974       DB       #42,#48,#59,#36,#35,#54,#47,#56       ;BHY65TGV
       DB       #4E,#4A,#55,#37,#34,#52,#46,#43       ;NJU74RFC
       DB       #4D,#4B,#49,#38,#33,#45,#44,#58       ;MKI83EDX
       DB       #3E,#4C,#4F,#39,#32,#57,#53,#5A       ;>LO92WSZ
       DB       #3A,#3D,#50,#30,#31,#51,#41,#3F       ;:=P01QA?
       DB       #3B,#3C       ;;<
L_B99E       DB       #10,#27,#E8,#03,#64,#00       ;.'h.d.
L_B9A4       DB       #0A,#00,#01,#00       ;....
L_B9A8       DB       #C0,#82,#C0,#82,#C0,#82,#1B,#83       ;@.@.@...
       DB       #76,#83,#76,#83,#D1,#83,#D1,#83       ;v.v.Q.Q.
       DB       #76,#83,#76,#83,#1B,#83,#1B,#83       ;v.v.....
       DB       #C0,#82,#C0,#82,#C0,#82       ;@.@.@.
L_B9C6       DB       #00       ;.
L_B9C7       DB       #29,#B7,#49,#B7,#69,#B7,#57,#B8       ;)7I7i7W8
       DB       #89,#B7,#CD,#B7,#0F,#B8,#37,#B8       ;.7M7.878
L_B9D7       DB       #00       ;.
L_B9D8       DB       #00,#00       ;..
L_B9DA       DB       #00,#01,#02,#03,#04,#05,#05,#06       ;........
       DB       #06,#06,#06,#06,#06,#06,#07,#07       ;........
       DB       #07,#07,#07,#07,#07,#07,#07,#07       ;........
       DB       #07,#07,#07,#07,#07,#07,#07,#07       ;........
       DB       #07,#07,#07,#07,#07,#07,#07,#07       ;........
L_BA02       DB       #B6,#BA,#B6,#BA,#B6,#BA,#B6,#BA       ;6:6:6:6:
       DB       #BE,#BA,#BE,#BA,#BE,#BA,#BE,#BA       ;>:>:>:>:
       DB       #C6,#BA,#C6,#BA,#CE,#BA,#D6,#BA       ;F:F:N:V:
       DB       #DE,#BA,#C6,#BA,#E6,#BA,#E6,#BA       ;^:F:f:f:
       DB       #E6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;f:F:F:F:
       DB       #EE,#BA,#C6,#BA,#F6,#BA,#FE,#BA       ;n:F:v:~:
       DB       #C6,#BA,#56,#BB,#C6,#BA,#5E,#BB       ;F:V;F:^;
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#5E,#BB       ;F:F:F:^;
       DB       #0E,#BB,#C6,#BA,#C6,#BA,#16,#BB       ;.;F:F:.;
       DB       #16,#BB,#16,#BB,#1E,#BB,#1E,#BB       ;.;.;.;.;
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;F:F:F:F:
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;F:F:F:F:
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;F:F:F:F:
       DB       #B6,#BA,#B6,#BA,#B6,#BA,#B6,#BA       ;6:6:6:6:
       DB       #C6,#BA,#26,#BB,#2E,#BB,#2E,#BB       ;F:&;.;.;
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;F:F:F:F:
       DB       #C6,#BA,#36,#BB,#36,#BB,#C6,#BA       ;F:6;6;F:
       DB       #B6,#BA,#B6,#BA,#C6,#BA,#0E,#BB       ;6:6:F:.;
       DB       #C6,#BA,#C6,#BA,#C6,#BA,#C6,#BA       ;F:F:F:F:
       DB       #C6,#BA,#3E,#BB,#3E,#BB,#C6,#BA       ;F:>;>;F:
       DB       #1E,#BB,#EE,#BA,#C6,#BA,#EE,#BA       ;.;n:F:n:
       DB       #C6,#BA,#F6,#BA,#EE,#BA,#C6,#BA       ;F:v:n:F:
       DB       #EE,#BA,#EE,#BA,#00,#01,#01,#06       ;n:n:....
       DB       #06,#06,#04,#08,#16,#05,#05,#14       ;........
       DB       #14,#14,#04,#08,#00,#01,#01,#0D       ;........
       DB       #0D,#0D,#04,#08,#0C,#12,#12,#12       ;........
       DB       #14,#14,#04,#08,#0C,#12,#12,#14       ;........
       DB       #14,#14,#04,#08,#00,#01,#01,#14       ;........
       DB       #14,#14,#04,#08,#10,#11,#11,#07       ;........
       DB       #07,#07,#04,#08,#00,#06,#06,#0D       ;........
       DB       #0D,#0D,#04,#08,#0A,#0B,#0B,#02       ;........
       DB       #04,#03,#04,#08,#0A,#0B,#0B,#0D       ;........
       DB       #0D,#0D,#04,#08,#10,#11,#11,#0D       ;........
       DB       #0D,#0D,#04,#08,#0E,#0F,#0F,#0D       ;........
       DB       #0D,#0D,#04,#08,#09,#09,#09,#02       ;........
       DB       #04,#03,#04,#08,#00,#01,#01,#02       ;........
       DB       #04,#03,#04,#08,#13,#01,#01,#14       ;........
       DB       #14,#14,#04,#08,#13,#14,#14,#14       ;........
       DB       #14,#14,#04,#08,#10,#11,#11,#06       ;........
       DB       #06,#06,#04,#08,#15,#01,#01,#0D       ;........
       DB       #0D,#0D,#04,#08,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#0C,#01,#01,#14       ;........
       DB       #14,#14,#04,#08,#11,#11,#11,#07       ;........
       DB       #07,#07,#04,#08,#14,#01,#01,#0D       ;........
       DB       #0D,#0D,#04,#08       ;....
L_BB66       DB       #19,#15,#16,#1A,#14,#18,#00,#11       ;........
       DB       #16,#14,#1A,#18,#11,#14,#16,#00       ;........
       DB       #14,#01,#01,#1A,#1A,#01,#00,#00       ;........
       DB       #12,#12,#1A,#1A,#01,#01,#00,#00       ;........
       DB       #01,#05,#01,#01,#01,#01,#01,#01       ;........
       DB       #05,#05,#05,#05,#02,#02,#02,#00       ;........
       DB       #05,#05,#05,#05,#01,#01,#00,#01       ;........
       DB       #1A,#14,#1A,#14,#05,#06,#04,#00       ;........
       DB       #01,#05,#01,#01,#01,#01,#01,#01       ;........
       DB       #08,#08,#02,#02,#06,#04,#02,#00       ;........
       DB       #19,#19,#09,#09,#09,#09,#09,#00       ;........
       DB       #05,#09,#09,#09,#09,#09,#09,#00       ;........
       DB       #15,#15,#08,#08,#06,#06,#06,#02       ;........
       DB       #12,#05,#05,#05,#01,#01,#00,#01       ;........
       DB       #19,#14,#06,#0A,#0A,#0A,#04,#02       ;........
       DB       #14,#14,#0A,#0A,#0A,#0A,#04,#00       ;........
       DB       #19,#15,#05,#06,#04,#04,#02,#04       ;........
       DB       #14,#14,#05,#06,#04,#04,#02,#04       ;........
       DB       #05,#05,#08,#08,#08,#06,#02,#00       ;........
       DB       #15,#15,#15,#1A,#1A,#11,#11,#00       ;........
       DB       #05,#1A,#1A,#05,#05,#05,#05,#00       ;........
       DB       #15,#1A,#15,#15,#05,#15,#15,#00       ;........
       DB       #05,#15,#05,#1A,#05,#1A,#05,#00       ;........
L_BC1E       DB       #11,#64,#01,#C8,#05,#4B,#91,#0D       ;.d.H.K..
       DB       #49,#04,#EC,#46,#AF,#0F,#35,#08       ;I.lF/.5.
       DB       #5C,#07,#75,#06,#31,#00       ;\.u.1.
L_BC34       DB       #46,#09,#37,#0F,#05,#09,#37,#0F       ;F.7...7.
       DB       #46,#09,#19,#0F,#05,#09,#37,#0F       ;F.....7.
       DB       #46,#09,#37,#00       ;F.7.
L_BC48       DB       #E6,#CD,#FF,#BE,#CA,#D2,#F0,#B9       ;fM.>JRp9
       DB       #EB,#00       ;k.
L_BC52       DB       #F0,#E8,#E0,#D8,#D0,#C8,#C0,#B8       ;ph`XPH@8
       DB       #B0,#A8,#A0,#98,#90,#88,#80,#78       ;0( ....x
       DB       #70,#68,#60,#58,#50,#48,#40,#38       ;ph`XPH@8
       DB       #30,#28,#20,#18,#10,#08,#00       ;0( ....
L_BC71       DB       #84,#9A,#BB,#A5,#94,#AC,#A5,#94       ;..;%.,%.
       DB       #AD,#00       ;-.
L_BC7B       DB       #20,#62,#4B,#17,#62,#2F,#3B,#53       ; bK.b/;S
       DB       #1B,#00       ;..
L_BC85       DB       #F0,#F0,#F0,#F0,#F0,#F0,#F0,#00       ;ppppppp.
;
L_BC8D       DB       #F0,#85
L_BC8F       DB       #F0,#45
L_BC91       DB       #E5,#90
L_BC93       DB       #E4,#51
L_BC95       DB       #F0,#45
L_BC97       DB       #F1,#44
L_BC99       DB       #A4,#C2,#82,#C7,#86
L_BC9E       DB       #68,#C8,#45
L_BCA1       DB       #67,#C9,#45
L_BCA4       DB       #F2,#83
L_BCA6       DB       #63,#C8,#4A
L_BCA9       DB       #E4,#86,#C6,#85
L_BCAD       DB       #6B,#C4,#46
L_BCB0       DB       #E2,#53
L_BCB2       DB       #EC,#49
L_BCB4       DB       #AA,#C2,#48,#81
L_BCB8       DB       #A6,#4F
L_BCBA       DB       #A4,#CC,#85
L_BCBD       DB       #68,#C8,#45
L_BCC0       DB       #AB,#C5,#85
L_BCC3       DB       #A9,#05,#87
L_BCC6       DB       #74,#01
L_BCC8       DB       #F2,#83
L_BCCA       DB       #E6,#8F
L_BCCC       DB       #F2,#43
L_BCCE       DB       #67,#06,#48
L_BCD1       DB       #E7,#4E
L_BCD3       DB       #71,#04
L_BCD5       DB       #EF,#86
L_BCD7       DB       #A4,#C5,#44,#07
L_BCDB       DB       #6B,#0A
L_BCDD       DB       #EC,#89
L_BCDF       DB       #A8,#04,#89
L_BCE2       DB       #E4,#91
L_BCE4       DB       #67,#03,#4B
L_BCE7       DB       #6A,#C5,#46
L_BCEA       DB       #E8,#4D
L_BCEC       DB       #6B,#03,#47
L_BCEF       DB       #E7,#8E
L_BCF1       DB       #AA,#CB
L_BCF3       DB       #AC,#C9
L_BCF5       DB       #A3,#08,#CA
L_BCF8       DB       #26,#8F
L_BCFA       DB       #E6,#4F
L_BCFC       DB       #6C,#02,#C7
L_BCFF       DB       #E4,#4A,#C3,#44
L_BD03       DB       #6D,#08
L_BD05       DB       #EB,#4A
L_BD07       DB       #66,#CF
L_BD09       DB       #68,#C9,#44
L_BD0C       DB       #EA,#4B
L_BD0E       DB       #A5,#CC,#84
L_BD11       DB       #64,#CC,#45
L_BD14       DB       #E5,#10
L_BD16       DB       #F2,#03
L_BD18       DB       #E4,#91
L_BD1A       DB       #E6,#0F
L_BD1C       DB       #F1,#84
L_BD1E       DB       #27,#49,#05
L_BD21       DB       #2A,#85,#06
L_BD24       DB       #E2,#87,#0C
L_BD27       DB       #EB,#8A
L_BD29       DB       #E3,#84,#C3,#4B
L_BD2D       DB       #EB,#45,#C5,#20
;
L_BD31       DW       L_BC8D
       DW       L_BC8F
       DW       L_BC91
       DW       L_BC93
       DW       L_BC95
       DW       L_BC97
       DW       L_BC99
       DW       L_BC9E
       DW       L_BCA1
       DW       L_BCA4
       DW       L_BCA6
       DW       L_BCA9
       DW       L_BCAD
       DW       L_BCB0
       DW       L_BCB2
       DW       L_BCB4
       DW       L_BCB8
       DW       L_BCBA
       DW       L_BCBD
       DW       L_BCC0
       DW       L_BCC3
       DW       L_BCC6
       DW       L_BCC8
       DW       L_BCCA
       DW       L_BCCC
       DW       L_BCCE
       DW       L_BCD1
       DW       L_BCD3
       DW       L_BCD5
       DW       L_BCD7
       DW       L_BCDB
       DW       L_BCDD
       DW       L_BCDF
       DW       L_BCE2
       DW       L_BCE4
       DW       L_BCE7
       DW       L_BCEA
       DW       L_BCEC
       DW       L_BCEF
       DW       L_BCF1
       DW       L_BCF3
       DW       L_BCF5
       DW       L_BCF8
       DW       L_BCFA
       DW       L_BCFC
       DW       L_BCFF
       DW       L_BD03
       DW       L_BD05
       DW       L_BD07
       DW       L_BD09
       DW       L_BD0C
       DW       L_BD0E
       DW       L_BD11
       DW       L_BD14
       DW       L_BD16
       DW       L_BD18
       DW       L_BD1A
       DW       L_BD1C
       DW       L_BD1E
       DW       L_BD21
       DW       L_BD24
       DW       L_BD27
       DW       L_BD29
       DW       L_BD2D
;
L_BDB1       DB       "0:",#00
L_BDB4       DB       "1:",#00
L_BDB7       DB       "2:",#00
L_BDBA       DB       "3:",#00
L_BDBD       DB       "4:",#00
L_BDC0       DB       "SELECT:",#00
L_BDC8       DB       "OPTION",#00
L_BDCF       DB       "PLAYER",#00
L_BDD6       DB       "KEYBOARD",#00
L_BDDF       DB       ":JOYSTICK",#00
L_BDE9       DB       "KEY",#00
L_BDED       DB       ":FOR:",#00
L_BDF3       DB       "FIRE",#00
L_BDF8       DB       "UP",#00
L_BDFB       DB       "DOWN",#00
L_BE00       DB       "LEFT",#00
L_BE05       DB       "RIGHT",#00
L_BE0B       DB       "PAUSE",#00
L_BE11       DB       "QUIT",#00
L_BE16       DB       "FINAL:V8:5>11>87",#00
L_BE27       DB       "ONE:",#00
L_BE2C       DB       "TWO:",#00
L_BE31       DB       "SINCLAIR",#00
L_BE3A       DB       "KEMPSTON",#00
L_BE43       DB       ":",#00
L_BE45       DB       "START:GAME",#00
L_BE50       DB       "GAME:",#00
L_BE56       DB       "KEYS",#00
L_BE5B       DB       "DEMO:",#00
;
L_BE61       DW       L_BDB1
       DW       L_BDB4
       DW       L_BDB7
       DW       L_BDBA
       DW       L_BDBD
       DW       L_BDC0
       DW       L_BDC8
       DW       L_BDCF
       DW       L_BDD6
       DW       L_BDDF
       DW       L_BDE9
       DW       L_BDED
       DW       L_BDF3
       DW       L_BDF8
       DW       L_BDFB
       DW       L_BE00
       DW       L_BE05
       DW       L_BE0B
       DW       L_BE11
       DW       L_BE16
       DW       L_BE27
       DW       L_BE2C
       DW       L_BE31
       DW       L_BE3A
       DW       L_BE43
       DW       L_BE45
       DW       L_BE50
       DW       L_BE56
       DW       L_BE5B
;
L_BE9B       DB       #05,#06,#FF,#00       ;....
L_BE9F       DB       #1C,#FF,#01,#14,#07,#FF,#02,#15       ;........
       DB       #07,#FF       ;..
L_BEA9       DB       #01,#16,#09,#FF,#02,#17,#09,#FF       ;........
       DB       #03,#08,#FF       ;...
L_BEB4       DB       #05,#1B,#18,#07       ;....
L_BEB8       DB       #01,#FF,#0A,#0B,#0C,#FF,#0A,#0B       ;........
       DB       #0D,#FF,#0A,#0B,#0E,#FF,#0A,#0B       ;........
       DB       #0F,#FF,#0A,#0B,#10,#FF,#0A,#0B       ;........
       DB       #11,#FF,#0A,#0B,#12,#FF       ;......
L_BED6       DB       #18,#18,#18,#07,#01,#18,#18,#07       ;........
       DB       #02,#FF,#01,#16,#01,#16,#02,#FF       ;........
       DB       #02,#16,#18,#18,#08,#FF,#03,#17       ;........
       DB       #18,#18,#08,#FF,#04,#08,#18,#18       ;........
       DB       #08,#FF,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00       ;..
;
Init	XOR	A
	OUT	(#FE),A
	SET	7,A
	LD	(L_B559),A
	LD	(L_B562),A
	LD	HL,L_6600
	LD	DE,font88 ;font
	LD	BC,#0158
	LDIR
	LD	B,#10
	LD	HL,L_40A8
L_BF1B	PUSH	HL
	PUSH	BC
	LD	A,#3A
	CALL	PrintChar88
	POP	BC
	POP	HL
	INC	L
	DJNZ	L_BF1B
	LD	HL,L_BF96
	LD	DE,L_F080
	LD	BC,#0064
	LDIR
	LD	HL,tmirror
	XOR	A
L_BF36	LD	B,A
	LD	C,A
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	SRL	C
	RLA
	LD	(HL),A
	LD	A,B
	INC	A
	JR	Z,L_BF58
	LD	L,A
	JR	L_BF36
;
L_BF58	LD	(L_B574),SP
	LD	SP,font88
	LD	HL,L_57A2
	LD	B,#54
L_BF64	PUSH	HL
	DEC	H
	LD	A,H
	CPL
	AND	#07
	JR	NZ,L_BF76
	LD	A,L
	SUB	#20
	LD	L,A
	JR	C,L_BF76
	LD	A,H
	ADD	A,#08
	LD	H,A
L_BF76	DJNZ	L_BF64
	LD	SP,(L_B574)
	LD	HL,Init
	LD	C,#F0
	LD	A,#BF
       ds 4
	;LD	I,A
	;IM	2
	LD	A,#C3
	LD	(0xF0F0),A
	LD	DE,IntHandler
	LD	(0xF0F0+1),DE
	JP	FillHL_Bplus1bytes_C
;
L_BF96       DB       #00,#01,#01,#01,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#02,#01       ;........
       DB       #01,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#01,#00,#00,#00,#FE,#FE,#00       ;.....~~.
       DB       #00,#FE,#00,#01,#04,#02,#04,#02       ;.~......
       DB       #01,#FF,#FC,#FE,#FC,#FE,#FF,#00       ;..|~|~..
       DB       #00,#00,#00,#01,#FF,#FF,#FF,#FF       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#FF,#FF,#FE,#00,#00       ;.....~..
       DB       #FF,#00,#00,#00,#00,#00,#00,#FF       ;........
       DB       #00,#00,#00,#00,#02,#FE,#01,#00       ;.....~..
       DB       #00,#FF,#FF,#FF,#00,#00,#00,#00       ;........
       DB       #00,#00       ;..
L_C000       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #02,#FF,#D8,#0F,#FF,#D8,#3F,#FF       ;..X..X?.
       DB       #D4,#7F,#FF,#EA,#00,#FF,#EA,#7F       ;T..j..j.
       DB       #FF,#EA,#FC,#FF,#F5,#FC,#FF,#F5       ;.j|.u|.u
       DB       #F8,#FF,#F5,#F8,#FF,#FA,#FC,#FF       ;x.ux.z|.
       DB       #FA,#FF,#FF,#F2,#F9,#FF,#EF,#67       ;z..ry.og
       DB       #FF,#D9,#54,#FF,#A1,#41,#FF,#40       ;.YT.!A.@
       DB       #A2,#FE,#C0,#A0,#FE,#A4,#A0,#FE       ;"~@ ~$ ~
       DB       #86,#50,#FE,#8F,#53,#FD,#07,#D2       ;.P~.S}.R
       DB       #01,#3F,#FF,#FF,#DF,#FF,#FF,#EF       ;.?.._..o
       DB       #FF,#FF,#6F,#FF,#FF,#5F,#FF,#FF       ;..o.._..
       DB       #DF,#FF,#FF,#5F,#FF,#FF,#2F,#FF       ;_.._../.
       DB       #FF,#5F,#FF,#FF,#5F,#FF,#FF,#DF       ;._.._.._
       DB       #FF,#FF,#0F,#FF,#FF,#F3,#FF,#FF       ;.....s..
       DB       #0D,#FF,#FF,#82,#FF,#FF,#02,#FF       ;........
       DB       #FF,#01,#7F,#FF,#11,#7F,#FF,#11       ;........
       DB       #BF,#FF,#30,#BF,#FF,#70,#BF,#FF       ;?.0?.p?.
       DB       #02,#FD,#0F,#6B,#FD,#0D,#EF,#FE       ;.}.k}.o~
       DB       #9F,#55,#FE,#81,#E1,#FE,#C0,#30       ;.U~.a~@0
       DB       #FF,#78,#30,#FF,#8D,#FD,#FF,#F3       ;.x0..}.s
       DB       #F8,#FF,#FB,#F8,#FF,#FB,#FC,#FF       ;x.{x.{|.
       DB       #FB,#FF,#FF,#F7,#1F,#FF,#F6,#1F       ;{..w..v.
       DB       #FF,#F4,#0F,#FF,#F4,#0F,#FF,#E8       ;.t..t..h
       DB       #0A,#FF,#E8,#1B,#FF,#E8,#31,#FF       ;..h..h1.
       DB       #D0,#50,#FF,#D0,#A0,#FF,#D0,#20       ;PP.P .P 
       DB       #01,#B0,#BF,#FF,#18,#BF,#FF,#38       ;.0?..?.8
       DB       #BF,#FF,#FC,#BF,#FF,#F9,#BF,#FF       ;?.|?.y?.
       DB       #E1,#7F,#FF,#C3,#7F,#FF,#4E,#FF       ;a..C..N.
       DB       #FF,#39,#FF,#FF,#37,#FF,#FF,#FB       ;.9..7..{
       DB       #FF,#FF,#8B,#FF,#FF,#8D,#FF,#FF       ;........
       DB       #45,#FF,#FF,#42,#FF,#FF,#23,#7F       ;E..B..#.
       DB       #FF,#01,#7F,#FF,#01,#BF,#FF,#80       ;.....?..
       DB       #BF,#FF,#40,#5F,#FF,#20,#5F,#FF       ;?.@_. _.
       DB       #80,#FF,#D0,#5F,#FF,#D0,#5F,#FF       ;..P_.P_.
       DB       #D0,#DF,#FF,#B0,#BF,#FF,#79,#BF       ;P_.0?.y?
       DB       #FE,#8A,#7F,#FD,#8E,#FF,#FD,#05       ;~..}..}.
       DB       #FF,#FD,#05,#FF,#FD,#8D,#FF,#FD       ;.}..}..}
       DB       #D3,#FF,#FB,#F7,#FF,#FB,#F7,#FF       ;S.{w.{w.
       DB       #FB,#F7,#FF,#FD,#F7,#FF,#FB,#CF       ;{w.}w.{O
       DB       #FF,#FB,#C0,#00,#F7,#C0,#3F,#EF       ;.{@.w@?o
       DB       #C3,#FF,#EF,#FF,#FF,#EF,#FC,#00       ;C.o..o|.
       DB       #81,#D0,#2F,#FF,#EC,#2F,#FF,#EE       ;.P/.l/.n
       DB       #2F,#FF,#F2,#EF,#FF,#FA,#6F,#FF       ;/.ro.zo.
       DB       #F6,#6F,#FF,#F4,#5F,#FF,#F4,#5F       ;vo.t_.t_
       DB       #FF,#EC,#5F,#FF,#EF,#EF,#FF,#EF       ;.l_.oo.o
       DB       #EF,#FF,#EF,#EF,#FF,#EF,#EF,#FF       ;o.oo.oo.
       DB       #F7,#9F,#FF,#F7,#BF,#FF,#F7,#CF       ;w..w?.wO
       DB       #FF,#03,#F3,#FF,#FF,#FD,#FF,#FF       ;..s..}..
       DB       #FE,#FF,#00,#01,#FF,#FF,#FF,#FF       ;~.......
       DB       #02,#FD,#0F,#6B,#FD,#0D,#EF,#FE       ;.}.k}.o~
       DB       #9F,#55,#FE,#81,#E1,#FE,#C0,#30       ;.U~.a~@0
       DB       #FF,#78,#30,#FF,#8D,#FD,#FF,#F3       ;.x0..}.s
       DB       #F8,#FF,#FB,#F8,#FF,#FB,#FC,#FF       ;x.{x.{|.
       DB       #FB,#1F,#FF,#FA,#0F,#FF,#F6,#0F       ;{..z..v.
       DB       #FF,#F4,#1F,#FF,#F4,#1E,#FF,#F4       ;.t..t..t
       DB       #1E,#FF,#F4,#0B,#FF,#F6,#09,#FF       ;..t..v..
       DB       #F6,#09,#FF,#F4,#10,#FF,#FA,#10       ;v..t..z.
       DB       #01,#B0,#BF,#FF,#18,#BF,#FF,#38       ;.0?..?.8
       DB       #BF,#FF,#FC,#BF,#FF,#F9,#BF,#FF       ;?.|?.y?.
       DB       #E1,#7F,#FF,#C3,#7F,#FF,#4E,#FF       ;a..C..N.
       DB       #FF,#39,#FF,#FF,#37,#FF,#FF,#FB       ;.9..7..{
       DB       #FF,#FF,#CB,#FF,#FF,#85,#FF,#FF       ;..K.....
       DB       #85,#FF,#FF,#42,#FF,#FF,#02,#FF       ;...B....
       DB       #FF,#01,#7F,#FF,#81,#7F,#FF,#C1       ;.......A
       DB       #7F,#FF,#C1,#BF,#FF,#41,#BF,#FF       ;..A?.A?.
       DB       #82,#FF,#FA,#37,#FF,#FA,#2F,#FF       ;..z7.z/.
       DB       #FB,#2F,#FF,#FB,#EF,#FF,#FA,#EF       ;{/.{o.zo
       DB       #FF,#F6,#60,#FF,#F4,#30,#FF,#F4       ;.v`.t0.t
       DB       #30,#FF,#F4,#31,#FF,#F6,#23,#FF       ;0.t1.v#.
       DB       #F7,#63,#FF,#EF,#E3,#FF,#EF,#E7       ;wc.oc.og
       DB       #FF,#F7,#E7,#FF,#FB,#CF,#FF,#FB       ;.wg.{O.{
       DB       #8F,#FF,#FB,#8F,#FF,#F7,#83,#FF       ;..{..w..
       DB       #CF,#FF,#FF,#BF,#FF,#FF,#CF,#BF       ;O..?..O?
       DB       #83,#A0,#BF,#FF,#B0,#BF,#FF,#D8       ;. ?.0?.X
       DB       #BF,#FF,#98,#BF,#FF,#7D,#7F,#FF       ;?..?.}..
       DB       #CB,#7F,#FF,#8E,#FF,#FF,#85,#FF       ;K.......
       DB       #FF,#8D,#FF,#FF,#9B,#FF,#FF,#FB       ;.......{
       DB       #FF,#FF,#FB,#FF,#FF,#B7,#FF,#FF       ;..{..7..
       DB       #CF,#FF,#FF,#BF,#FF,#FF,#DF,#FF       ;O..?.._.
       DB       #FF,#E7,#FF,#FF,#FB,#FF,#FF,#FC       ;.g..{..|
       DB       #FF,#FF,#FC,#FF,#FF,#FF,#7F,#FF       ;..|.....
       DB       #02,#FD,#0F,#6B,#FD,#0D,#EF,#FE       ;.}.k}.o~
       DB       #9F,#55,#FE,#81,#E1,#FE,#C0,#30       ;.U~.a~@0
       DB       #FF,#78,#30,#FF,#8D,#FD,#FF,#F7       ;.x0..}.w
       DB       #F8,#FF,#F7,#F8,#FF,#F7,#3C,#FF       ;x.wx.w<.
       DB       #F6,#3F,#FF,#F6,#1F,#FF,#FA,#1E       ;v?.v..z.
       DB       #FF,#FA,#0E,#FF,#FA,#06,#FF,#FB       ;.z..z..{
       DB       #06,#FF,#FD,#C3,#FF,#FD,#E3,#FF       ;..}C.}c.
       DB       #FE,#B3,#FF,#FE,#81,#FF,#FF,#41       ;~3.~...A
       DB       #01,#B0,#BF,#FF,#18,#BF,#FF,#38       ;.0?..?.8
       DB       #BF,#FF,#FC,#BF,#FF,#F9,#BF,#FF       ;?.|?.y?.
       DB       #E1,#7F,#FF,#C3,#7F,#FF,#4E,#FF       ;a..C..N.
       DB       #FF,#39,#FF,#FF,#27,#FF,#FF,#EF       ;.9..'..o
       DB       #FF,#FF,#6F,#FF,#FF,#37,#FF,#FF       ;..o..7..
       DB       #17,#FF,#FF,#1B,#FF,#FF,#0B,#FF       ;........
       DB       #FF,#0B,#FF,#FF,#0D,#FF,#FF,#85       ;........
       DB       #FF,#FF,#85,#FF,#FF,#85,#FF,#FF       ;........
       DB       #02,#FF,#FF,#A1,#FF,#FF,#A1,#FF       ;...!..!.
       DB       #FF,#B9,#FF,#FF,#BB,#FF,#FF,#BF       ;.9..;..?
       DB       #FF,#FF,#7B,#FF,#FE,#BF,#FF,#FE       ;..{.~?.~
       DB       #A1,#FF,#FC,#A1,#FF,#FB,#E1,#FF       ;!.|!.{a.
       DB       #FB,#FB,#FF,#FB,#FF,#FF,#FB,#FF       ;{{.{..{.
       DB       #FF,#F7,#BF,#FF,#EF,#DF,#FF,#EF       ;.w?.o_.o
       DB       #87,#FF,#EF,#C7,#FF,#E7,#EF,#FF       ;..oG.go.
       DB       #DF,#FF,#FF,#E0,#FF,#FF,#FF,#01       ;_..`....
       DB       #01,#C5,#FF,#FF,#C5,#FF,#FF,#85       ;.E..E...
       DB       #FF,#FF,#8B,#FF,#FF,#B7,#FF,#FF       ;.....7..
       DB       #EF,#FF,#FF,#DF,#FF,#FF,#BF,#FF       ;o.._..?.
       DB       #FF,#7F,#FF,#FF,#7F,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#7F,#FF,#FF,#BF,#FF,#FF       ;.....?..
       DB       #BF,#FF,#FF,#7F,#FF,#FF,#7F,#FF       ;?.......
       DB       #FF,#81,#FF,#FF,#FE,#FF,#FF,#F9       ;....~..y
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #02,#FD,#0F,#6B,#FD,#0D,#EF,#FE       ;.}.k}.o~
       DB       #9F,#55,#FE,#81,#E1,#FE,#C0,#30       ;.U~.a~@0
       DB       #FF,#78,#30,#FF,#8D,#FD,#FF,#F1       ;.x0..}.q
       DB       #F8,#FF,#FB,#F8,#FF,#FB,#FC,#FF       ;x.{x.{|.
       DB       #FB,#FF,#FF,#FB,#1F,#FF,#FA,#0F       ;{..{..z.
       DB       #FF,#FA,#0F,#FF,#FA,#0F,#FF,#FA       ;.z..z..z
       DB       #07,#FF,#FB,#05,#FF,#FB,#05,#FF       ;..{..{..
       DB       #FB,#84,#FF,#FD,#44,#FF,#FD,#04       ;{..}D.}.
       DB       #01,#B0,#BF,#FF,#18,#BF,#FF,#38       ;.0?..?.8
       DB       #BF,#FF,#FC,#BF,#FF,#F9,#BF,#FF       ;?.|?.y?.
       DB       #E1,#7F,#FF,#C3,#7F,#FF,#4E,#FF       ;a..C..N.
       DB       #FF,#39,#FF,#FF,#37,#FF,#FF,#F7       ;.9..7..w
       DB       #FF,#FF,#9B,#FF,#FF,#8B,#FF,#FF       ;........
       DB       #4D,#FF,#FF,#45,#FF,#FF,#02,#FF       ;M..E....
       DB       #FF,#02,#FF,#FF,#03,#7F,#FF,#81       ;........
       DB       #7F,#FF,#C1,#7F,#FF,#41,#BF,#FF       ;..A..A?.
       DB       #80,#FF,#FE,#C5,#FF,#FE,#C5,#FF       ;..~E.~E.
       DB       #FE,#CD,#FF,#FE,#FD,#FF,#FD,#BB       ;~M.~}.};
       DB       #FF,#FD,#6B,#FF,#FB,#17,#FF,#FA       ;.}k.{..z
       DB       #17,#FF,#FA,#17,#FF,#FA,#37,#FF       ;..z..z7.
       DB       #FB,#77,#FF,#F7,#F7,#FF,#F7,#F7       ;{w.ww.ww
       DB       #FF,#F7,#F7,#FF,#F9,#EF,#FF,#FB       ;.ww.yo.{
       DB       #DF,#FF,#FB,#80,#FF,#F7,#C0,#FF       ;_.{..w@.
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#F7,#FF       ;o..o..w.
       DB       #81,#A1,#7F,#FF,#D1,#7F,#FF,#D7       ;.!..Q..W
       DB       #7F,#FF,#B7,#7F,#FF,#A1,#7F,#FF       ;..7..!..
       DB       #A1,#7F,#FF,#A1,#BF,#FF,#B1,#BF       ;!..!?.1?
       DB       #FF,#BB,#BF,#FF,#BF,#BF,#FF,#BF       ;.;?.??.?
       DB       #BF,#FF,#DF,#7F,#FF,#EE,#FF,#FF       ;?._..n..
       DB       #DE,#FF,#FF,#DF,#7F,#FF,#DF,#7F       ;^.._.._.
       DB       #FF,#1F,#BF,#FF,#1F,#CF,#FF,#C3       ;..?..O.C
       DB       #F7,#FF,#FF,#F7,#FF,#FF,#CF,#FF       ;w..w..O.
       DB       #02,#FF,#FC,#F0,#FF,#FB,#FE,#FF       ;..|p.{~.
       DB       #F7,#FF,#FF,#F0,#02,#FF,#F7,#F5       ;w..p..wu
       DB       #FF,#F7,#CD,#FF,#EF,#C4,#FF,#EF       ;.wM.oD.o
       DB       #C2,#FF,#EF,#85,#FF,#EF,#C4,#FF       ;B.o..oD.
       DB       #DF,#B8,#FF,#DF,#E0,#FF,#DE,#10       ;_8._`.^.
       DB       #FF,#BA,#08,#FF,#A0,#04,#FF,#40       ;.:.. ..@
       DB       #C2,#FF,#50,#31,#FE,#C0,#00,#FE       ;B.P1~@.~
       DB       #D0,#40,#FD,#50,#70,#FD,#48,#58       ;P@}Pp}HX
       DB       #84,#FF,#FF,#FF,#FF,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#BF,#FF,#FF,#5F,#FF,#FF       ;..?.._..
       DB       #AF,#FF,#FF,#D7,#FF,#FF,#6B,#FF       ;/..W..k.
       DB       #FF,#B5,#FF,#FF,#DA,#FF,#FF,#ED       ;.5..Z..m
       DB       #7F,#FF,#F6,#BF,#FF,#FB,#5F,#FF       ;..v?.{_.
       DB       #FD,#A1,#FF,#FE,#D6,#FF,#FF,#69       ;}!.~V..i
       DB       #7F,#00,#32,#FF,#C0,#46,#7F,#60       ;..2.@F.`
       DB       #7B,#BF,#2F,#FD,#DF,#30,#32,#5F       ;{?/}_02_
       DB       #02,#FB,#30,#86,#FB,#10,#1D,#FB       ;.{0.{..{
       DB       #10,#0C,#FD,#18,#08,#FD,#98,#08       ;..}..}..
       DB       #FE,#88,#0C,#FE,#C8,#7C,#FF,#6F       ;~..~H|.o
       DB       #FC,#FF,#BF,#FE,#FF,#BF,#FF,#FF       ;|.?~.?..
       DB       #DF,#FF,#FF,#EF,#0F,#FF,#EE,#0E       ;_..o..n.
       DB       #FF,#EE,#06,#FF,#F4,#06,#FF,#F6       ;.n..t..v
       DB       #06,#FF,#FA,#06,#FF,#FA,#06,#FF       ;..z..z..
       DB       #FA,#06,#FF,#FD,#07,#FF,#FD,#05       ;z..}..}.
       DB       #01,#00,#07,#CF,#C0,#7F,#F7,#FF       ;...O@.w.
       DB       #80,#57,#00,#00,#77,#00,#00,#0F       ;.W..w...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #5F,#FF,#FF,#2F,#FF,#FF,#2F,#FF       ;_../../.
       DB       #FF,#17,#FF,#FF,#0B,#FF,#FF,#0D       ;........
       DB       #FF,#FF,#05,#FF,#FF,#05,#FF,#FF       ;........
       DB       #80,#FF,#FD,#05,#FF,#FD,#85,#FF       ;..}..}..
       DB       #FE,#85,#FF,#FC,#85,#FF,#FB,#C5       ;~..|..{E
       DB       #FF,#F5,#4B,#FF,#E8,#0B,#FF,#E8       ;.uK.h..h
       DB       #37,#FF,#D0,#6F,#FF,#B8,#9F,#FF       ;7.Po.8..
       DB       #7F,#7F,#FF,#7F,#7F,#FF,#7F,#7F       ;........
       DB       #FE,#FF,#7F,#FE,#FC,#FF,#FE,#F1       ;~..~|.~q
       DB       #FF,#FE,#F0,#00,#FD,#E0,#3F,#FB       ;.~p.}`?{
       DB       #E3,#FF,#FB,#FF,#FF,#FB,#FE,#00       ;c.{..{~.
       DB       #88,#85,#FF,#FF,#C2,#FF,#FF,#9E       ;....B...
       DB       #FF,#FF,#82,#FF,#FF,#82,#FF,#FF       ;........
       DB       #42,#FF,#FF,#61,#7F,#FF,#B3,#7F       ;B..a..3.
       DB       #FF,#BF,#BF,#FF,#BF,#BF,#FF,#BF       ;.??.??.?
       DB       #BF,#FF,#DF,#BF,#FF,#DF,#7F,#FF       ;?._?._..
       DB       #EF,#7F,#FF,#F7,#BF,#FF,#F7,#9F       ;o..w?.w.
       DB       #FF,#07,#E7,#FF,#87,#F9,#FF,#FF       ;..g..y..
       DB       #FE,#FF,#E0,#01,#FF,#1F,#FF,#FF       ;~.`.....
       DB       #89,#FF,#F3,#CF,#FF,#EF,#F7,#FF       ;..sO.ow.
       DB       #DF,#FB,#FF,#C0,#1B,#FF,#DF,#D7       ;_{.@.._W
       DB       #FF,#DF,#37,#FF,#BF,#17,#FF,#BF       ;._7.?..?
       DB       #0B,#FF,#BE,#17,#FF,#7F,#17,#FF       ;..>.....
       DB       #7E,#F7,#FF,#7C,#8F,#FF,#4F,#BF       ;~w.|..O?
       DB       #FE,#90,#BF,#FE,#80,#5F,#FD,#88       ;~.?~._}.
       DB       #6F,#FD,#84,#37,#FD,#83,#17,#FD       ;o}.7}..}
       DB       #88,#08,#FD,#CC,#0B,#FD,#44,#0C       ;..}L.}D.
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #00,#FF,#FF,#1F,#7F,#FF,#39,#BF       ;......9?
       DB       #FF,#11,#DF,#FF,#33,#2F,#FF,#66       ;.._.3/.f
       DB       #DF,#FF,#8D,#5F,#FF,#09,#2F,#FF       ;_.._../.
       DB       #02,#FD,#23,#00,#FD,#21,#80,#FE       ;.}#.}!.~
       DB       #B0,#43,#FE,#98,#3C,#FF,#48,#0C       ;0C~.<.H.
       DB       #FF,#A8,#04,#FF,#D8,#0E,#FF,#EF       ;.(..X..o
       DB       #FE,#FF,#EF,#FE,#FF,#EF,#FF,#FF       ;~.o~.o..
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#EE,#1E       ;o..o..n.
       DB       #FF,#EE,#0E,#FF,#F4,#0E,#FF,#F4       ;.n..t..t
       DB       #06,#FF,#F4,#06,#FF,#F6,#06,#FF       ;..t..v..
       DB       #FA,#05,#FF,#FA,#05,#FF,#FA,#04       ;z..z..z.
       DB       #8A,#36,#97,#FF,#C0,#4B,#FF,#00       ;.6..@K..
       DB       #25,#FF,#FF,#D2,#FF,#FF,#E9,#7F       ;%..R..i.
       DB       #FF,#F4,#BF,#FF,#FA,#5F,#FF,#FD       ;.t?.z_.}
       DB       #2F,#FF,#FE,#EF,#FF,#FF,#2F,#FF       ;/.~o../.
       DB       #FF,#DF,#3F,#FF,#FF,#DF,#FF,#FF       ;._?.._..
       DB       #6F,#FF,#FF,#17,#FF,#FF,#0B,#FF       ;o.......
       DB       #FF,#0B,#FF,#FF,#05,#FF,#FF,#02       ;........
       DB       #FF,#FF,#82,#FF,#FF,#41,#FF,#FF       ;.....A..
       DB       #80,#FF,#FD,#05,#FF,#FD,#05,#FF       ;..}..}..
       DB       #FD,#85,#FF,#FC,#85,#FF,#FB,#C5       ;}..|..{E
       DB       #FF,#F5,#85,#FF,#E8,#8B,#FF,#E8       ;.u..h..h
       DB       #37,#FF,#D0,#6F,#FF,#B8,#DF,#FF       ;7.Po.8_.
       DB       #7F,#3F,#FF,#7F,#7F,#FF,#7F,#7F       ;.?......
       DB       #FE,#FF,#7F,#FE,#FC,#FF,#FE,#F3       ;~..~|.~s
       DB       #FF,#FE,#F0,#00,#FD,#E0,#3F,#FB       ;.~p.}`?{
       DB       #E3,#FF,#FB,#FF,#FF,#FB,#FE,#00       ;c.{..{~.
       DB       #81,#A0,#BF,#FF,#D8,#BF,#FF,#D3       ;. ?.X?.S
       DB       #BF,#FF,#D0,#BF,#FF,#D0,#BF,#FF       ;?.P?.P?.
       DB       #D0,#BF,#FF,#E8,#BF,#FF,#DC,#DF       ;P?.h?.\_
       DB       #FF,#DF,#DF,#FF,#DF,#EF,#FF,#DF       ;.__._o._
       DB       #EF,#FF,#EF,#EF,#FF,#EF,#9F,#FF       ;o.oo.o..
       DB       #F7,#BF,#FF,#F7,#BF,#FF,#F7,#9F       ;w?.w?.w.
       DB       #FF,#07,#E7,#FF,#E7,#F9,#FF,#FF       ;..g.gy..
       DB       #FE,#FF,#80,#01,#FF,#7F,#FF,#FF       ;~.......
       DB       #8B,#FF,#F9,#E7,#FF,#F7,#DB,#FF       ;..yg.w[.
       DB       #EF,#CB,#FF,#E0,#25,#FF,#EF,#F2       ;oK.`%.or
       DB       #FF,#EF,#99,#FF,#DF,#8C,#FF,#DF       ;.o.._.._
       DB       #86,#FF,#DF,#09,#FF,#BF,#88,#FF       ;.._..?..
       DB       #BF,#7B,#FF,#B9,#E7,#FF,#A0,#37       ;?{.9g. 7
       DB       #FF,#A1,#1B,#FF,#60,#CD,#FF,#40       ;.!..`M.@
       DB       #02,#FF,#42,#01,#FF,#43,#00,#FF       ;..B..C..
       DB       #41,#E1,#FE,#C0,#79,#FE,#C0,#EF       ;Aa~@y~@o
       DB       #8C,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #7F,#FF,#FF,#BF,#FF,#FF,#5F,#FF       ;...?.._.
       DB       #FF,#2F,#FF,#FF,#97,#FF,#FF,#4B       ;./.....K
       DB       #FF,#FF,#A5,#FF,#FF,#D2,#FF,#FF       ;..%..R..
       DB       #E9,#07,#FF,#F4,#BB,#FF,#02,#6B       ;i..t;..k
       DB       #FF,#C1,#2B,#FF,#3D,#DD,#FF,#03       ;.A+.=]..
       DB       #36,#FF,#01,#62,#FF,#FF,#F2,#FF       ;6..b..r.
       DB       #02,#FE,#B1,#F8,#FE,#91,#08,#FE       ;.~1x~..~
       DB       #90,#08,#FE,#D8,#0C,#FF,#6C,#04       ;..~X..l.
       DB       #FF,#AC,#04,#FF,#BE,#04,#FF,#DF       ;.,..>.._
       DB       #FE,#FF,#EF,#FE,#FF,#EF,#FF,#FF       ;~.o~.o..
       DB       #EF,#FF,#FF,#EF,#0E,#FF,#EE,#06       ;o..o..n.
       DB       #FF,#EE,#02,#FF,#F6,#02,#FF,#FB       ;.n..v..{
       DB       #02,#FF,#FB,#02,#FF,#FB,#02,#FF       ;..{..{..
       DB       #FD,#07,#FF,#FD,#06,#FF,#FD,#04       ;}..}..}.
       DB       #8D,#FF,#DE,#FF,#FF,#E1,#FF,#FF       ;..^..a..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#7F,#FF,#FF,#BF       ;.......?
       DB       #FF,#FF,#DF,#FF,#FF,#5F,#FF,#FF       ;.._.._..
       DB       #2F,#FF,#FF,#17,#FF,#FF,#0B,#FF       ;/.......
       DB       #FF,#05,#FF,#FF,#05,#FF,#FF,#02       ;........
       DB       #FF,#FF,#83,#7F,#FF,#C1,#7F,#FF       ;.....A..
       DB       #80,#FF,#FD,#05,#FF,#FE,#85,#FF       ;..}..~..
       DB       #FE,#85,#FF,#FC,#85,#FF,#FB,#85       ;~..|..{.
       DB       #FF,#F4,#8B,#FF,#E8,#37,#FF,#E8       ;.t..h7.h
       DB       #2F,#FF,#D8,#6F,#FF,#B8,#DF,#FF       ;/.Xo.8_.
       DB       #7F,#3F,#FF,#7F,#7F,#FF,#7F,#7F       ;.?......
       DB       #FE,#FF,#7F,#FE,#FC,#FF,#FE,#F3       ;~..~|.~s
       DB       #FF,#FE,#F0,#00,#FD,#E0,#3F,#FB       ;.~p.}`?{
       DB       #E3,#FF,#FB,#FF,#FF,#FB,#FE,#00       ;c.{..{~.
       DB       #81,#E0,#BF,#FF,#D8,#BF,#FF,#D3       ;.`?.X?.S
       DB       #BF,#FF,#D0,#BF,#FF,#D0,#BF,#FF       ;?.P?.P?.
       DB       #D0,#BF,#FF,#C8,#BF,#FF,#DC,#DF       ;P?.H?.\_
       DB       #FF,#DF,#DF,#FF,#DF,#EF,#FF,#DF       ;.__._o._
       DB       #EF,#FF,#EF,#EF,#FF,#EF,#9F,#FF       ;o.oo.o..
       DB       #F7,#BF,#FF,#F7,#BF,#FF,#F7,#9F       ;w?.w?.w.
       DB       #FF,#07,#E7,#FF,#E7,#F9,#FF,#FF       ;..g.gy..
       DB       #FE,#FF,#80,#01,#FF,#7F,#FF,#FF       ;~.......
       DB       #9F,#FF,#FC,#F3,#FF,#FB,#FD,#FF       ;..|s.{}.
       DB       #F7,#FE,#FF,#F0,#06,#FF,#F7,#F5       ;w~.p..wu
       DB       #FF,#F7,#CD,#FF,#EF,#C5,#FF,#EF       ;.wM.oE.o
       DB       #C2,#FF,#EF,#85,#FF,#DF,#C5,#FF       ;B.o.._E.
       DB       #DF,#BD,#FF,#DF,#23,#FF,#BB,#FC       ;_=._#.;|
       DB       #FF,#40,#83,#FE,#90,#08,#FE,#80       ;.@.~..~.
       DB       #00,#FD,#60,#00,#FA,#60,#E0,#FA       ;.}`.z``z
       DB       #34,#3F,#F4,#34,#0F,#F4,#32,#1B       ;4?t4.t2.
       DB       #8E,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #E3,#FF,#FF,#DC,#FF,#00,#1F,#7F       ;c..\....
       DB       #80,#0C,#BF,#60,#10,#47,#1F,#E0       ;..?`.G.`
       DB       #7B,#00,#07,#AB,#20,#3B,#57,#FF       ;{..+ ;W.
       DB       #C2,#CB,#00,#00,#25,#00,#00,#12       ;BK..%...
       DB       #02,#E8,#DC,#31,#E8,#8C,#01,#E9       ;.h\1h..i
       DB       #C6,#01,#EC,#42,#02,#F4,#42,#02       ;F.lB.tB.
       DB       #FA,#23,#83,#FD,#9F,#FF,#FE,#C3       ;z#.}..~C
       DB       #FF,#FF,#33,#FF,#FF,#CB,#FF,#FF       ;..3..K..
       DB       #F7,#C7,#FF,#FB,#C3,#FF,#FD,#83       ;wG.{C.}.
       DB       #FF,#FD,#81,#FF,#FD,#81,#FF,#FE       ;.}..}..~
       DB       #81,#FF,#FE,#81,#FF,#FE,#81,#FF       ;..~..~..
       DB       #FF,#41,#FF,#FF,#41,#FF,#FF,#41       ;.A..A..A
       DB       #90,#FF,#FF,#E9,#FF,#FF,#F4,#FF       ;...i..t.
       DB       #FF,#FA,#FF,#FF,#FD,#FF,#FF,#FE       ;.z..}..~
       DB       #FF,#FF,#FF,#7F,#FF,#FF,#BF,#FF       ;......?.
       DB       #FF,#BF,#FF,#FF,#DF,#FF,#FF,#5F       ;.?.._.._
       DB       #FF,#FF,#2F,#FF,#FF,#2F,#FF,#FF       ;../../..
       DB       #17,#FF,#FF,#17,#FF,#FF,#0B,#FF       ;........
       DB       #FF,#0B,#FF,#FF,#0B,#FF,#FF,#05       ;........
       DB       #FF,#FF,#85,#FF,#FF,#85,#FF,#FF       ;........
       DB       #80,#FF,#FF,#41,#FF,#FF,#41,#FF       ;...A..A.
       DB       #FE,#82,#FF,#FE,#82,#FF,#FC,#85       ;~..~..|.
       DB       #FF,#FB,#85,#FF,#F4,#1B,#FF,#E8       ;.{..t..h
       DB       #77,#FF,#D8,#2F,#FF,#B8,#5F,#FF       ;w.X/.8_.
       DB       #7F,#BF,#FF,#7F,#7F,#FF,#7F,#7F       ;.?......
       DB       #FE,#FF,#7F,#FE,#FC,#FF,#FE,#F3       ;~..~|.~s
       DB       #FF,#FE,#F0,#00,#FD,#E0,#3F,#FB       ;.~p.}`?{
       DB       #E2,#FF,#FB,#FF,#FF,#FB,#FE,#00       ;b.{..{~.
       DB       #92,#85,#FF,#FF,#45,#FF,#FF,#36       ;....E..6
       DB       #FF,#FF,#6E,#FF,#FF,#42,#FF,#FF       ;..n..B..
       DB       #41,#7F,#FF,#41,#7F,#FF,#61,#7F       ;A..A..a.
       DB       #FF,#B3,#7F,#FF,#BF,#BF,#FF,#BF       ;.3..??.?
       DB       #BF,#FF,#BF,#BF,#FF,#BF,#7F,#FF       ;?.??.?..
       DB       #CF,#7F,#FF,#EF,#BF,#FF,#F7,#9F       ;O..o?.w.
       DB       #FF,#07,#E7,#FF,#E7,#F9,#FF,#FF       ;..g.gy..
       DB       #FE,#FF,#00,#01,#FF,#FF,#FF,#FF       ;~.......
       DB       #02,#FF,#FD,#F8,#FF,#FB,#F8,#FF       ;..}x.{x.
       DB       #FC,#EE,#FF,#F9,#F1,#FF,#F6,#38       ;|n.yq.v8
       DB       #FF,#E8,#03,#FF,#D0,#02,#FF,#20       ;.h..P.. 
       DB       #04,#FE,#C0,#49,#FD,#03,#D2,#FA       ;.~@I}.Rz
       DB       #3F,#24,#FA,#13,#C8,#FA,#15,#90       ;?$z.Hz..
       DB       #FD,#15,#AE,#FE,#CE,#40,#FF,#23       ;}..~N@.#
       DB       #20,#FF,#A1,#E0,#FF,#A2,#80,#FF       ; .!`."..
       DB       #5C,#80,#FF,#51,#C0,#FF,#A1,#FD       ;\..Q@.!}
       DB       #01,#39,#7F,#FF,#32,#FF,#FF,#E5       ;.9..2..e
       DB       #FF,#FF,#CB,#FF,#FF,#97,#FF,#FF       ;..K.....
       DB       #37,#FF,#FF,#7B,#FF,#FF,#CD,#FF       ;7..{..M.
       DB       #FF,#06,#FF,#FF,#0B,#7F,#FF,#89       ;........
       DB       #BF,#FF,#08,#8F,#FF,#1C,#77,#FF       ;?.....w.
       DB       #FF,#88,#7F,#20,#FF,#9F,#20,#0E       ;... .. .
       DB       #6F,#40,#03,#B7,#40,#00,#0F,#BF       ;o@.7@..?
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #02,#FF,#FD,#FF,#FF,#FD,#FF,#FF       ;..}..}..
       DB       #FD,#FF,#FF,#FD,#E3,#FF,#FD,#C1       ;}..}c.}A
       DB       #FF,#FE,#80,#FF,#FE,#80,#FF,#FF       ;.~..~...
       DB       #40,#FF,#FF,#A0,#FF,#FF,#D0,#FF       ;@.. ..P.
       DB       #FF,#EC,#FF,#FF,#F2,#FF,#FF,#F1       ;.l..r..q
       DB       #FF,#FF,#CE,#FF,#FF,#B8,#FF,#FF       ;..N..8..
       DB       #70,#FF,#FC,#F0,#FF,#F3,#70,#FF       ;p.|p.sp.
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#EF,#DF       ;o..o..o_
       DB       #01,#E7,#FF,#FF,#D9,#FF,#FF,#86       ;.g..Y...
       DB       #7F,#FF,#81,#9F,#FF,#80,#6F,#FF       ;......o.
       DB       #C0,#13,#FF,#60,#0D,#FF,#30,#02       ;@..`..0.
       DB       #FF,#1C,#01,#7F,#13,#81,#7F,#08       ;........
       DB       #E1,#7F,#09,#82,#FF,#0E,#05,#FF       ;a.......
       DB       #8E,#0B,#FF,#8F,#17,#FF,#7F,#EF       ;.......o
       DB       #FF,#3F,#9F,#FF,#FF,#BF,#FF,#FB       ;.?...?.{
       DB       #7F,#FF,#E0,#FF,#FF,#9F,#FF,#FF       ;..`.....
       DB       #02,#FF,#EF,#83,#FF,#F7,#83,#FF       ;..o..w..
       DB       #F7,#81,#FF,#F7,#80,#FF,#FB,#80       ;w..w..{.
       DB       #FF,#FC,#00,#FF,#FF,#FF,#FF,#FF       ;.|......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#C0,#FF       ;......@.
       DB       #C0,#3F,#FF,#BF,#FF,#FF,#C0,#00       ;@?.?..@.
       DB       #01,#BF,#FF,#FF,#BF,#FF,#FF,#BF       ;.?..?..?
       DB       #FF,#FF,#7F,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#00,#FF,#FF,#FF       ;........
       DB       #01,#FF,#FF,#FE,#FF,#00,#01,#FF       ;...~....
       DB       #02,#D8,#1E,#94,#EC,#0F,#C8,#F3       ;.X..l.Hs
       DB       #84,#64,#FC,#60,#3E,#FF,#9C,#70       ;.d|`>..p
       DB       #FF,#E7,#DE,#FF,#E9,#00,#FF,#EE       ;.g^.i..n
       DB       #00,#FF,#F2,#10,#FF,#F2,#40,#FF       ;..r..r@.
       DB       #F7,#01,#FF,#EF,#E1,#FF,#EF,#FE       ;w..oa.o~
       DB       #FF,#DF,#FF,#FF,#D8,#3F,#FF,#B0       ;._..X?.0
       DB       #03,#FF,#B0,#00,#FF,#B0,#00,#FF       ;..0..0..
       DB       #D8,#00,#FF,#EE,#07,#FF,#F1,#FC       ;X..n..q|
       DB       #01,#88,#3F,#1B,#0F,#C0,#07,#18       ;..?..@..
       DB       #3F,#FF,#17,#FF,#FF,#17,#FF,#FF       ;?.......
       DB       #EF,#FF,#FF,#5F,#FF,#FF,#5F,#FF       ;o.._.._.
       DB       #FF,#DF,#FF,#FF,#BF,#FF,#FF,#7F       ;._..?...
       DB       #FF,#FF,#FF,#FF,#FF,#0F,#FF,#FF       ;........
       DB       #F0,#FF,#FF,#0F,#1F,#FF,#F0,#EF       ;p.....po
       DB       #FF,#1C,#17,#FF,#07,#17,#FF,#02       ;........
       DB       #17,#FF,#82,#6F,#FF,#03,#DF,#FF       ;...o.._.
       DB       #02,#FF,#FF,#70,#FF,#FE,#F0,#FF       ;...p.~p.
       DB       #F1,#F9,#FF,#EF,#FF,#FF,#DF,#FB       ;qy.o.._{
       DB       #FF,#DF,#36,#FF,#EF,#0F,#FF,#F7       ;._6.o..w
       DB       #C7,#FF,#FB,#C0,#FF,#FC,#00,#FF       ;G.{@.|..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #01,#0F,#7F,#FF,#3E,#FF,#FF,#F9       ;....>..y
       DB       #FF,#FF,#F7,#FF,#FF,#0F,#FF,#FF       ;..w.....
       DB       #FF,#FF,#FF,#7F,#FF,#FF,#BF,#FF       ;......?.
       DB       #FF,#7F,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#F0,#FF       ;......p.
       DB       #F8,#0F,#FF,#F7,#FF,#FF,#F8,#00       ;x..w..x.
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#07,#FF,#FF,#F8       ;.......x
       DB       #0F,#FF,#FF,#F7,#FF,#00,#0F,#FF       ;...w....
       DB       #02,#FF,#F9,#EE,#FF,#86,#19,#FE       ;..yn...~
       DB       #7A,#19,#FD,#8E,#19,#FA,#07,#9F       ;z.}..z..
       DB       #F4,#1F,#9A,#F4,#3B,#96,#F4,#E3       ;t..t;.tc
       DB       #CA,#F4,#37,#C9,#F4,#17,#C6,#FA       ;Jt7It.Fz
       DB       #17,#C3,#FA,#0F,#E1,#FA,#07,#A3       ;.Cz.az.#
       DB       #FD,#01,#B5,#FE,#C6,#B0,#FF,#3C       ;}.5~F0.<
       DB       #18,#FF,#D0,#0E,#FF,#D8,#27,#FF       ;..P..X'.
       DB       #EF,#80,#FF,#EC,#00,#FF,#F4,#00       ;o..l..t.
       DB       #01,#00,#00,#7F,#FF,#FF,#BF,#00       ;......?.
       DB       #00,#5F,#FF,#FF,#BF,#00,#00,#7F       ;._..?...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#7F,#FF,#FF,#BF       ;.......?
       DB       #FF,#FF,#DF,#FF,#FF,#2F,#FF,#FF       ;.._../..
       DB       #17,#FF,#FF,#17,#FF,#FF,#17,#FF       ;........
       DB       #FF,#97,#FF,#FF,#17,#FF,#FF,#6F       ;.......o
       DB       #FF,#FF,#5F,#FF,#FF,#5F,#FF,#FF       ;.._.._..
       DB       #93,#FF,#F6,#40,#FF,#FA,#80,#FF       ;..v@.z..
       DB       #FA,#01,#FF,#FB,#81,#FF,#FB,#FF       ;z..{..{.
       DB       #FF,#FB,#FF,#FF,#F7,#FF,#FF,#F4       ;.{..w..t
       DB       #7F,#FF,#EC,#1F,#FF,#D8,#0F,#FF       ;..l..X..
       DB       #D8,#10,#FE,#38,#17,#FD,#E0,#2F       ;X.~8.}`/
       DB       #FB,#E0,#5F,#FB,#C0,#BF,#F7,#C1       ;{`_{@?wA
       DB       #7F,#F7,#82,#00,#F7,#84,#7E,#EF       ;.w..w.~o
       DB       #CF,#FF,#EF,#FF,#FF,#F0,#00,#00       ;O.o..p..
       DB       #A3,#BF,#FF,#FF,#BF,#FF,#FF,#00       ;#?..?...
       DB       #0F,#FF,#FF,#F3,#FF,#E0,#0D,#FF       ;...s.`..
       DB       #00,#02,#FF,#00,#02,#FF,#00,#42       ;.......B
       DB       #FF,#87,#85,#FF,#7E,#0B,#FF,#84       ;....~...
       DB       #17,#FF,#EC,#37,#FF,#EF,#F7,#FF       ;..l7.ow.
       DB       #DF,#EF,#FF,#9F,#EF,#FF,#7E,#1F       ;_o..o.~.
       DB       #FF,#7C,#FF,#FF,#FF,#3F,#FF,#FF       ;.|...?..
       DB       #DF,#FF,#FF,#EF,#FF,#00,#1F,#FF       ;_..o....
       DB       #94,#FF,#FF,#78,#FF,#FE,#FE,#FF       ;...x.~~.
       DB       #FD,#FF,#FF,#FC,#03,#FF,#FB,#FA       ;}..|..{z
       DB       #FF,#F7,#E6,#FF,#F7,#E2,#FF,#F7       ;.wf.wb.w
       DB       #C1,#FF,#EF,#C2,#00,#0F,#F2,#E0       ;A.oB..r`
       DB       #1F,#BE,#98,#61,#60,#66,#80,#20       ;.>.a`f. 
       DB       #19,#84,#10,#E6,#6C,#00,#F9,#9C       ;...fl.y.
       DB       #10,#F2,#67,#90,#F4,#18,#6F,#F4       ;.rg.t.ot
       DB       #23,#9E,#F3,#08,#80,#FD,#FF,#FF       ;#.s..}..
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#3F,#FF,#FF,#CF       ;....?..O
       DB       #FF,#FF,#37,#FF,#FF,#0B,#FF,#FF       ;..7.....
       DB       #0D,#FF,#FF,#85,#FF,#FF,#85,#FF       ;........
       DB       #FF,#C5,#FF,#FF,#E2,#FF,#FF,#02       ;.E..b...
       DB       #FF,#FF,#0D,#FF,#FF,#F3,#FF,#FF       ;.....s..
       DB       #02,#FF,#FF,#FB,#FF,#FF,#F7,#FF       ;...{..w.
       DB       #FF,#EF,#FF,#FF,#E0,#FF,#FF,#DF       ;.o..`.._
       DB       #FF,#FF,#DF,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #BE,#FF,#FF,#BE,#FF,#FF,#BF,#FF       ;>..>..?.
       DB       #FF,#3F,#FF,#FE,#FF,#FF,#FD,#8E       ;.?.~..}.
       DB       #FF,#FB,#04,#FF,#FA,#02,#FF,#FA       ;.{..z..z
       DB       #01,#FF,#FA,#00,#FF,#FD,#00,#FF       ;..z..}..
       DB       #FD,#20,#FF,#FD,#18,#FF,#FD,#06       ;} .}..}.
       DB       #95,#CF,#FF,#FF,#F7,#FF,#FF,#FB       ;.O..w..{
       DB       #FF,#FF,#1B,#FF,#FF,#97,#FF,#FF       ;........
       DB       #37,#FF,#FF,#17,#FF,#FF,#0B,#FF       ;7.......
       DB       #FF,#17,#FF,#FF,#17,#FF,#FF,#F7       ;.......w
       DB       #FF,#FF,#4F,#FF,#FF,#E7,#FF,#FF       ;..O..g..
       DB       #1B,#FF,#FF,#0D,#FF,#FF,#EE,#FF       ;......n.
       DB       #FF,#BA,#FF,#FF,#F9,#0F,#FF,#3E       ;.:..y..>
       DB       #63,#FF,#01,#88,#00,#00,#13,#FF       ;c.......
       DB       #93,#FF,#FD,#11,#FF,#FD,#20,#FF       ;..}..} .
       DB       #FD,#00,#FF,#FD,#81,#FF,#FB,#FF       ;}..}..{.
       DB       #FF,#FB,#FF,#FF,#F7,#FF,#FF,#F4       ;.{..w..t
       DB       #7F,#FF,#EC,#1F,#FF,#D8,#0F,#FF       ;..l..X..
       DB       #D8,#10,#FE,#38,#17,#FD,#E0,#2F       ;X.~8.}`/
       DB       #FB,#E0,#5F,#FB,#C0,#BF,#F7,#C1       ;{`_{@?wA
       DB       #7F,#F7,#82,#00,#F7,#84,#7E,#EF       ;.w..w.~o
       DB       #CF,#FF,#EF,#FF,#FF,#F0,#00,#00       ;O.o..p..
       DB       #01,#BD,#8D,#FF,#48,#F3,#FF,#C7       ;.=..Hs.G
       DB       #8F,#FF,#FF,#F3,#FF,#E0,#0D,#FF       ;...s.`..
       DB       #00,#02,#FF,#00,#02,#FF,#00,#42       ;.......B
       DB       #FF,#87,#85,#FF,#7E,#0B,#FF,#04       ;....~...
       DB       #17,#FF,#0C,#37,#FF,#0F,#F7,#FF       ;...7..w.
       DB       #1F,#EF,#FF,#1F,#EF,#FF,#7E,#1F       ;.o..o.~.
       DB       #FF,#7C,#FF,#FF,#FF,#3F,#FF,#FF       ;.|...?..
       DB       #DF,#FF,#FF,#EF,#FF,#00,#1F,#FF       ;_..o....
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#00,#00,#FF,#FF,#FF,#7F       ;........
       DB       #00,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #89,#FF,#FE,#FF,#FF,#FD,#7F,#FF       ;..~..}..
       DB       #FB,#7F,#FF,#F5,#7F,#FF,#F5,#0F       ;{..u..u.
       DB       #FF,#EA,#F3,#FF,#EB,#FD,#FF,#D7       ;.js.k}.W
       DB       #FE,#FF,#D4,#02,#FF,#AF,#C5,#FF       ;~.T../E.
       DB       #AF,#CD,#FF,#57,#85,#FF,#5F,#82       ;/M.W.._.
       DB       #FE,#AF,#85,#FE,#AF,#C5,#FD,#CF       ;~/.~/E}O
       DB       #BD,#FA,#3F,#93,#F2,#31,#99,#EB       ;=z?.r1.k
       DB       #C0,#C6,#E8,#40,#01,#E8,#30,#31       ;@Fh@.h01
       DB       #02,#F6,#1C,#20,#ED,#83,#41,#E9       ;.v. m.Ai
       DB       #E0,#C1,#F7,#78,#03,#F4,#2E,#06       ;`Awx.t..
       DB       #F4,#2B,#CD,#FA,#28,#FC,#FA,#24       ;t+Mz(|z$
       DB       #41,#FA,#C4,#01,#FD,#87,#F1,#FE       ;AzD.}.q~
       DB       #07,#FF,#FF,#E7,#FF,#FF,#EF,#FF       ;...g..o.
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#EE       ;.o..o..n
       DB       #1F,#FF,#EC,#0F,#FF,#EC,#0F,#FF       ;..l..l..
       DB       #EC,#0F,#FF,#EC,#0D,#FF,#E8,#0B       ;l..l..h.
       DB       #97,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FC,#3F,#FF,#FD,#80,#00,#FD,#C0       ;|?.}..}@
       DB       #07,#FD,#40,#1F,#FE,#A0,#3F,#FE       ;.}@.~ ?~
       DB       #A0,#00,#FF,#50,#7F,#FF,#50,#FC       ; ..P..P|
       DB       #FF,#A8,#FC,#FF,#A8,#F8,#FF,#D5       ;.(|.(x.U
       DB       #F8,#FF,#D7,#FC,#FF,#EB,#FF,#FF       ;x.W|.k..
       DB       #DB,#F1,#FF,#DD,#D1,#FF,#A5,#80       ;[q.]Q.%.
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#3F,#FF       ;......?.
       DB       #FF,#DF,#FF,#FF,#EF,#FF,#FF,#6F       ;._..o..o
       DB       #FF,#FF,#5F,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #5F,#FF,#FF,#2F,#FF,#FF,#5F,#FF       ;_../.._.
       DB       #FF,#5F,#FF,#FF,#CF,#FF,#FF,#F3       ;._..O..s
       DB       #FF,#FF,#0D,#FF,#FF,#02,#FF,#FF       ;........
       DB       #02,#FF,#A6,#80,#FF,#A2,#84,#FF       ;..&.."..
       DB       #43,#44,#FE,#83,#40,#FE,#87,#AC       ;CD~.@~.,
       DB       #FE,#8F,#B8,#FD,#3E,#D8,#FD,#0B       ;~.8}>X}.
       DB       #0B,#FD,#07,#0F,#FD,#80,#B2,#FE       ;.}..}.2~
       DB       #61,#C0,#FF,#9F,#E1,#FF,#E1,#FF       ;a@..a.a.
       DB       #FF,#FD,#FF,#FF,#FD,#CF,#FF,#FD       ;.}..}O.}
       DB       #C3,#FF,#FD,#C1,#FF,#FE,#81,#FF       ;C.}A.~..
       DB       #FE,#83,#FF,#FE,#83,#FF,#FE,#82       ;~..~..~.
       DB       #01,#01,#7F,#FF,#01,#7F,#FF,#01       ;........
       DB       #7F,#FF,#31,#7F,#FF,#F1,#7F,#FF       ;..1..q..
       DB       #10,#BF,#FF,#10,#BF,#FF,#78,#BF       ;.?..?.x?
       DB       #FF,#88,#BF,#FF,#00,#BF,#FF,#03       ;..?..?..
       DB       #BF,#FF,#FC,#7F,#FF,#E3,#FF,#FF       ;?.|..c..
       DB       #F7,#FF,#FF,#FB,#FF,#FF,#C4,#FF       ;w..{..D.
       DB       #FF,#C3,#7F,#FF,#C0,#BF,#FF,#A0       ;.C..@?. 
       DB       #5F,#FF,#50,#2F,#FF,#40,#17,#FF       ;_.P/.@..
       DB       #80,#FF,#FE,#82,#FF,#FE,#82,#FF       ;..~..~..
       DB       #FE,#85,#FF,#FE,#85,#FF,#FC,#85       ;~..~..|.
       DB       #FF,#FB,#8B,#FF,#F4,#8B,#FF,#E8       ;.{..t..h
       DB       #77,#FF,#C8,#6F,#FF,#B8,#5F,#FF       ;w.Ho.8_.
       DB       #BD,#DF,#FF,#BF,#BF,#FF,#7E,#7F       ;=_.??.~.
       DB       #FF,#7E,#FF,#FE,#F9,#FF,#FD,#E7       ;.~.~y.}g
       DB       #FF,#FB,#E0,#00,#FB,#E0,#3F,#FB       ;.{`.{`?{
       DB       #FF,#FF,#FB,#FF,#FF,#F8,#00,#00       ;..{..x..
       DB       #81,#A0,#0B,#FF,#D8,#05,#FF,#E6       ;. ..X..f
       DB       #05,#FF,#F9,#02,#FF,#FE,#C1,#7F       ;..y..~A.
       DB       #FE,#E1,#7F,#FD,#41,#7F,#FA,#0E       ;~a.}A.z.
       DB       #FF,#F6,#05,#FF,#EE,#1B,#FF,#EF       ;.v..n..o
       DB       #E7,#FF,#EF,#EF,#FF,#E7,#EF,#FF       ;g.oo.go.
       DB       #DD,#9F,#FF,#9E,#7F,#FF,#BE,#7F       ;].....>.
       DB       #FF,#3F,#9F,#FF,#0F,#EF,#FF,#FF       ;.?...o..
       DB       #EF,#FF,#FF,#F7,#FF,#00,#07,#FF       ;o..w....
       DB       #02,#FF,#FF,#E6,#FF,#FF,#DE,#FF       ;...f..^.
       DB       #FF,#BE,#FF,#FF,#80,#FF,#FF,#BE       ;.>.....>
       DB       #FF,#FF,#BE,#FF,#FF,#BE,#FF,#FF       ;..>..>..
       DB       #BE,#FF,#FF,#7E,#FF,#FF,#7D,#FF       ;>..~..}.
       DB       #FF,#70,#FF,#FE,#C0,#FF,#FD,#00       ;.p.~@.}.
       DB       #FF,#FA,#01,#FF,#FA,#07,#FF,#FA       ;.z..z..z
       DB       #0F,#FF,#FD,#0F,#FF,#FD,#0C,#FF       ;..}..}..
       DB       #FD,#80,#FF,#FE,#80,#FF,#FE,#80       ;}..~..~.
       DB       #01,#58,#FB,#FF,#3F,#DB,#FF,#3A       ;.X{.?[.:
       DB       #47,#FF,#32,#2F,#FF,#31,#2F,#FF       ;G.2/.1/.
       DB       #11,#17,#FF,#11,#17,#FF,#19,#97       ;........
       DB       #FF,#1E,#17,#FF,#18,#2F,#FF,#38       ;...../.8
       DB       #2F,#FF,#70,#5F,#FF,#F0,#BF,#FF       ;/.p_.p?.
       DB       #D1,#7F,#FF,#96,#FF,#FF,#99,#FF       ;Q.......
       DB       #FF,#17,#FF,#FF,#F7,#FF,#FF,#2F       ;....w../
       DB       #FF,#FF,#2F,#FF,#FF,#2F,#FF,#FF       ;../../..
       DB       #02,#FF,#FF,#40,#FF,#FF,#40,#FF       ;...@..@.
       DB       #FF,#40,#FF,#FF,#40,#FF,#FF,#70       ;.@..@..p
       DB       #FF,#FE,#FF,#FF,#FE,#FF,#FF,#FE       ;.~..~..~
       DB       #FF,#FF,#FE,#FF,#FF,#FE,#FF,#FF       ;..~..~..
       DB       #FE,#C7,#FF,#FE,#83,#FF,#FE,#81       ;~G.~..~.
       DB       #FF,#FE,#81,#FF,#FE,#83,#FF,#FE       ;.~..~..~
       DB       #81,#FF,#FE,#81,#FF,#FE,#81,#FF       ;..~..~..
       DB       #FE,#81,#FF,#FE,#81,#FF,#FE,#81       ;~..~..~.
       DB       #01,#5F,#FF,#FF,#5F,#FF,#FF,#5F       ;._.._.._
       DB       #FF,#FF,#5F,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #DF,#FF,#FF,#DF,#FF,#FF,#DF,#FF       ;_.._.._.
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#97       ;.o..o...
       DB       #FF,#FF,#97,#FF,#FF,#8B,#FF,#FF       ;........
       DB       #C5,#FF,#FF,#45,#FF,#FF,#22,#FF       ;E..E..".
       DB       #FF,#82,#FF,#FF,#81,#7F,#FF,#41       ;.......A
       DB       #7F,#FF,#41,#7F,#FF,#21,#BF,#FF       ;..A..!?.
       DB       #02,#FF,#F8,#82,#FF,#F7,#82,#FF       ;..x..w..
       DB       #E8,#44,#FF,#C8,#78,#FF,#B0,#30       ;hD.Hx.00
       DB       #FF,#70,#C1,#FE,#F9,#83,#FE,#FF       ;.pA~y.~.
       DB       #03,#FD,#FC,#03,#FB,#FC,#03,#F7       ;.}|.{|.w
       DB       #B8,#07,#F7,#C0,#1F,#F7,#80,#1F       ;8.w@.w..
       DB       #F7,#80,#1F,#F7,#C0,#0F,#F7,#C0       ;w..w@.w@
       DB       #07,#F0,#00,#03,#FF,#FF,#FD,#F0       ;.p....}p
       DB       #00,#00,#CF,#FF,#FF,#BF,#FF,#FF       ;..O..?..
       DB       #01,#30,#BF,#FF,#18,#BF,#FF,#38       ;.0?..?.8
       DB       #BF,#FF,#49,#7F,#FF,#C7,#7F,#FF       ;?.I..G..
       DB       #82,#FF,#FF,#85,#FF,#FF,#ED,#FF       ;......m.
       DB       #FF,#FB,#FF,#FF,#FB,#FF,#FF,#E7       ;.{..{..g
       DB       #FF,#FF,#9F,#FF,#FF,#BF,#FF,#FF       ;.....?..
       DB       #BF,#FF,#FF,#BF,#FF,#FF,#DF,#FF       ;?..?.._.
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#07       ;.o..o...
       DB       #FF,#FF,#FB,#FF,#FF,#07,#FF,#FF       ;..{.....
       DB       #02,#FF,#FF,#D0,#FF,#FF,#90,#FF       ;...P....
       DB       #FF,#42,#FF,#FE,#87,#FF,#FD,#07       ;.B.~..}.
       DB       #FF,#FD,#0B,#FF,#FD,#0B,#FF,#FD       ;.}..}..}
       DB       #1F,#FF,#FD,#AF,#FF,#FE,#83,#FF       ;..}/.~..
       DB       #FE,#81,#FF,#FF,#40,#FF,#FF,#A0       ;~...@.. 
       DB       #FF,#FF,#B0,#FF,#FF,#A8,#FF,#FF       ;..0..(..
       DB       #A6,#FF,#FF,#A0,#FF,#FF,#A0,#FF       ;&.. .. .
       DB       #FF,#A0,#FF,#FF,#D0,#FF,#FF,#D0       ;. ..P..P
       DB       #01,#41,#1F,#FF,#1E,#6F,#FF,#FA       ;.A...o.z
       DB       #17,#FF,#F9,#0B,#FF,#F8,#C5,#FF       ;..y..xE.
       DB       #F8,#72,#FF,#F8,#42,#FF,#FC,#82       ;xr.xB.|.
       DB       #FF,#FD,#C2,#FF,#0E,#25,#FF,#00       ;.}B..%..
       DB       #05,#FF,#00,#0B,#FF,#00,#17,#FF       ;........
       DB       #00,#2F,#FF,#40,#DF,#FF,#43,#DF       ;./.@_.C_
       DB       #FF,#00,#5F,#FF,#40,#BF,#FF,#40       ;.._.@?.@
       DB       #BF,#FF,#01,#7F,#FF,#41,#7F,#FF       ;?....A..
       DB       #02,#FF,#FF,#E8,#FF,#FF,#E8,#FF       ;...h..h.
       DB       #FF,#EC,#FF,#FF,#EF,#FF,#FF,#DF       ;.l..o.._
       DB       #FF,#FF,#DF,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #BF,#FF,#FF,#BF,#FF,#FF,#41,#FF       ;?..?..A.
       DB       #FF,#40,#FF,#FE,#C0,#FF,#FE,#80       ;.@.~@.~.
       DB       #FF,#FE,#81,#FF,#FE,#81,#FF,#FD       ;.~..~..}
       DB       #02,#FF,#FD,#02,#FF,#FD,#04,#FF       ;..}..}..
       DB       #FD,#08,#FF,#FA,#10,#FF,#FA,#A0       ;}..z..z 
       DB       #01,#02,#FF,#FF,#42,#FF,#FF,#06       ;....B...
       DB       #FF,#FF,#FE,#FF,#FF,#FE,#FF,#FF       ;..~..~..
       DB       #FE,#FF,#FF,#FE,#FF,#FF,#FF,#7F       ;~..~....
       DB       #FF,#FF,#7F,#FF,#F9,#7F,#FF,#E0       ;....y..`
       DB       #BF,#FF,#E0,#BF,#FF,#20,#5F,#FF       ;?.`?. _.
       DB       #20,#5F,#FF,#10,#5F,#FF,#10,#2F       ; _.._../
       DB       #FF,#08,#2F,#FF,#08,#2F,#FF,#04       ;../../..
       DB       #2F,#FF,#02,#37,#FF,#02,#8B,#FF       ;/..7....
       DB       #96,#FF,#F4,#5F,#FF,#E8,#5F,#FF       ;..t_.h_.
       DB       #D8,#5F,#FF,#90,#BF,#FF,#71,#7F       ;X_..?.q.
       DB       #FE,#FF,#7F,#FE,#FF,#7F,#FF,#7F       ;~..~....
       DB       #7F,#FF,#7F,#7F,#FF,#78,#FF,#FE       ;.....x.~
       DB       #FB,#FF,#FE,#E7,#FF,#FC,#EF,#FF       ;{.~g.|o.
       DB       #FB,#EF,#FF,#FB,#EF,#FF,#FB,#EF       ;{o.{o.{o
       DB       #FF,#FC,#1F,#FF,#FF,#FF,#FF,#FC       ;.|.....|
       DB       #00,#00,#FB,#FF,#FF,#F7,#FF,#FF       ;..{..w..
       DB       #98,#FD,#05,#FF,#FD,#05,#FF,#FE       ;.}..}..~
       DB       #8E,#FF,#FF,#7E,#FF,#FF,#7F,#7F       ;...~....
       DB       #FF,#7F,#7F,#FF,#76,#FF,#FF,#9E       ;....v...
       DB       #FF,#FF,#DF,#7F,#FF,#EF,#BF,#FF       ;.._..o?.
       DB       #EF,#BF,#FF,#EF,#BF,#FF,#DF,#7F       ;o?.o?._.
       DB       #FF,#DE,#FF,#FF,#D9,#FF,#FF,#C7       ;.^..Y..G
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#00       ;........
       DB       #01,#FF,#FF,#FE,#7F,#FF,#FF,#BF       ;...~...?
       DB       #02,#FF,#E0,#04,#FF,#DE,#1A,#FF       ;..`..^..
       DB       #DB,#FC,#FF,#E2,#5C,#FF,#F4,#4C       ;[|.b\.tL
       DB       #FF,#F4,#8C,#FF,#E8,#88,#FF,#E8       ;.t..h..h
       DB       #88,#FF,#E9,#98,#FF,#E8,#78,#FF       ;..i..hx.
       DB       #F4,#18,#FF,#F4,#1C,#FF,#FA,#0E       ;t..t..z.
       DB       #FF,#FD,#0F,#FF,#FE,#8B,#FF,#FF       ;.}..~...
       DB       #69,#FF,#FF,#99,#FF,#FF,#E8,#FF       ;i.....h.
       DB       #FF,#EF,#FF,#FF,#F4,#FF,#FF,#F4       ;.o..t..t
       DB       #01,#3F,#7F,#FF,#60,#FF,#FF,#7B       ;.?..`..{
       DB       #FF,#FF,#7D,#FF,#FF,#01,#FF,#FF       ;..}.....
       DB       #7D,#FF,#FF,#7D,#FF,#FF,#7D,#FF       ;}..}..}.
       DB       #FF,#7D,#FF,#FF,#7E,#FF,#FF,#BE       ;.}..~..>
       DB       #FF,#FF,#0E,#FF,#FF,#03,#7F,#FF       ;........
       DB       #00,#BF,#FF,#80,#5F,#FF,#E0,#5F       ;.?.._.`_
       DB       #FF,#F0,#5F,#FF,#F0,#BF,#FF,#30       ;.p_.p?.0
       DB       #BF,#FF,#01,#BF,#FF,#01,#7F,#FF       ;?..?....
       DB       #02,#FF,#FF,#FA,#FF,#FF,#FA,#FF       ;...z..z.
       DB       #FF,#FA,#FF,#FF,#FA,#FF,#FF,#FB       ;.z..z..{
       DB       #FF,#FF,#FB,#FF,#FF,#FB,#FF,#FF       ;..{..{..
       DB       #FB,#FF,#FF,#F7,#FF,#FF,#F7,#FF       ;{..w..w.
       DB       #FF,#E9,#FF,#FF,#E9,#FF,#FF,#D1       ;.i..i..Q
       DB       #FF,#FF,#A3,#FF,#FF,#A2,#FF,#FF       ;..#.."..
       DB       #44,#FF,#FF,#41,#FF,#FE,#81,#FF       ;D..A.~..
       DB       #FE,#82,#FF,#FE,#82,#FF,#FD,#84       ;~..~..}.
       DB       #01,#02,#FF,#FF,#02,#FF,#FF,#02       ;........
       DB       #FF,#FF,#02,#FF,#FF,#0E,#FF,#FF       ;........
       DB       #FF,#7F,#FF,#FF,#7F,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#7F,#FF,#FF,#7F,#FF,#E3       ;.......c
       DB       #7F,#FF,#C1,#7F,#FF,#81,#7F,#FF       ;..A.....
       DB       #81,#7F,#FF,#C1,#7F,#FF,#81,#7F       ;...A....
       DB       #FF,#81,#7F,#FF,#81,#7F,#FF,#81       ;........
       DB       #7F,#FF,#81,#7F,#FF,#81,#7F,#FF       ;........
       DB       #02,#FF,#FD,#0C,#FF,#FD,#18,#FF       ;..}..}..
       DB       #FD,#1C,#FF,#FE,#92,#FF,#FE,#E3       ;}..~..~c
       DB       #FF,#FF,#41,#FF,#FF,#A1,#FF,#FF       ;..A..!..
       DB       #B7,#FF,#FF,#DF,#FF,#FF,#DF,#FF       ;7.._.._.
       DB       #FF,#E7,#FF,#FF,#F9,#FF,#FF,#FD       ;.g..y..}
       DB       #FF,#FF,#FD,#FF,#FF,#FD,#FF,#FF       ;..}..}..
       DB       #FB,#FF,#FF,#F7,#FF,#FF,#F7,#FF       ;{..w..w.
       DB       #FF,#E0,#FF,#FF,#DF,#FF,#FF,#C0       ;.`.._..@
       DB       #01,#41,#1F,#FF,#41,#EF,#FF,#22       ;.A..Ao."
       DB       #17,#FF,#1E,#13,#FF,#0C,#0D,#FF       ;........
       DB       #83,#0E,#FF,#C1,#9F,#7F,#C0,#FF       ;...A..@.
       DB       #7F,#C0,#3F,#BF,#C0,#3F,#DF,#E0       ;.@??@?_`
       DB       #1D,#EF,#F8,#03,#EF,#F8,#01,#EF       ;.ox.ox.o
       DB       #F8,#01,#EF,#F0,#03,#EF,#E0,#03       ;x.op.o`.
       DB       #EF,#C0,#00,#0F,#BF,#FF,#FF,#00       ;o@..?...
       DB       #00,#0F,#FF,#FF,#F3,#FF,#FF,#FD       ;....s..}
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #07,#FF,#FC,#F9,#FF,#F3,#8E,#FF       ;..|y.s..
       DB       #EC,#C1,#7F,#D0,#04,#BF,#D0,#02       ;lA.P.?P.
       DB       #5F,#A0,#00,#2F,#A0,#C1,#2F,#40       ;_ ./ A/@
       DB       #E0,#2F,#40,#BC,#CF,#41,#00,#5F       ;`/@<OA._
       DB       #99,#42,#01,#5F,#46,#20,#5F,#8A       ;.B._F _.
       DB       #10,#5F,#89,#00,#AF,#91,#00,#AF       ;._../../
       DB       #91,#00,#97,#90,#F8,#89,#91,#FF       ;....x...
       DB       #B6,#91,#FF,#C9,#91,#FF,#CD,#A1       ;6..I..M!
       DB       #E3,#CB,#B1,#81,#43,#99,#80,#C0       ;cK1.C..@
       DB       #88,#80,#DF,#CE,#80,#DF,#54,#40       ;.._N._T@
       DB       #DF,#68,#40,#5F,#F4,#20,#5F,#94       ;_h@_t _.
       DB       #20,#6F,#0A,#10,#6F,#0A,#10,#6F       ; o..o..o
       DB       #03,#F5,#0C,#6F,#F5,#0C,#6F,#FA       ;.u.ou.oz
       DB       #8E,#6F,#FA,#BB,#EF,#FD,#41,#DF       ;.oz;o}A_
       DB       #FD,#41,#5F,#FE,#A1,#5F,#FE,#A2       ;}A_~!_~"
       DB       #BF,#FD,#D6,#BF,#FD,#DF,#BF,#FD       ;?}V?}_?}
       DB       #EF,#BF,#FC,#EF,#BF,#FB,#D7,#BF       ;o?|o?{W?
       DB       #FB,#F5,#7F,#FB,#FE,#FF,#F3,#DE       ;{u.{~.s^
       DB       #FF,#EF,#DF,#7F,#EF,#EF,#1F,#F3       ;.o_.oo.s
       DB       #F7,#EF,#8F,#FF,#F7,#7F,#FC,#0F       ;wo..w.|.
       DB       #9A,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#F0,#FF,#FF       ;.....p..
       DB       #CF,#7F,#FF,#B9,#BF,#FF,#44,#5F       ;O..9?.D_
       DB       #FF,#84,#2F,#FF,#80,#2F,#FF,#80       ;../../..
       DB       #17,#FF,#82,#17,#FF,#82,#17,#FF       ;........
       DB       #83,#17,#FF,#85,#EF,#FF,#84,#2F       ;....o../
       DB       #FF,#88,#2F,#FF,#88,#2F,#FF,#88       ;../../..
       DB       #5F,#FF,#C9,#5F,#FF,#8A,#5F,#FF       ;_.I_.._.
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#00,#FF,#FE,#F0,#FF       ;.....~p.
       DB       #F1,#BF,#FF,#EF,#FE,#FF,#EF,#FF       ;q?.o~.o.
       DB       #FF,#DF,#FD,#FF,#DF,#F0,#FF,#DF       ;._}._p._
       DB       #70,#FF,#DC,#38,#FF,#DC,#0C,#FF       ;p.\8.\..
       DB       #DE,#02,#FF,#EF,#FF,#FF,#EF,#FF       ;^..o..o.
       DB       #9B,#88,#5F,#FF,#8F,#5F,#FF,#8F       ;.._.._..
       DB       #DF,#FF,#4F,#EF,#FF,#47,#EF,#FF       ;_.Oo.Go.
       DB       #47,#EF,#FF,#44,#EF,#FF,#44,#57       ;Go.Do.DW
       DB       #FF,#C2,#57,#FF,#C2,#57,#FF,#FB       ;.BW.BW.{
       DB       #57,#FF,#68,#D7,#FF,#23,#33,#FF       ;W.hW.#3.
       DB       #E0,#CC,#FF,#60,#F3,#3F,#20,#CC       ;`L.`s? L
       DB       #CF,#21,#CB,#33,#11,#88,#CC,#01       ;O!K3..L.
       DB       #98,#33,#83,#FF,#8D,#FF,#FF,#FF       ;.3......
       DB       #9C,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#C7,#FF,#FF,#39,#FF,#FE       ;..G..9.~
       DB       #CE,#FF,#FD,#82,#FF,#FA,#03,#FF       ;N.}..z..
       DB       #F4,#05,#FF,#EC,#09,#FF,#E8,#01       ;t..l..h.
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #C0,#FF,#FC,#30,#FF,#FB,#7B,#FF       ;@.|0.{{.
       DB       #F7,#FF,#FF,#EF,#FF,#FF,#EF,#FD       ;w..o..o}
       DB       #FF,#EF,#FC,#FF,#EE,#1C,#FF,#EC       ;.o|.n..l
       DB       #1C,#FF,#E8,#02,#FF,#E0,#00,#FF       ;..h..`..
       DB       #F0,#00,#FF,#CF,#FF,#FF,#BF,#FF       ;p..O..?.
       DB       #9D,#FF,#DC,#39,#FF,#A0,#61,#FF       ;..\9. a.
       DB       #A1,#91,#FF,#A1,#0E,#FF,#B1,#09       ;!..!..1.
       DB       #FF,#51,#97,#FE,#F1,#2F,#FE,#F1       ;.Q.~q/~q
       DB       #5F,#01,#F9,#BF,#81,#F9,#87,#F1       ;_.y?.y.q
       DB       #39,#97,#9A,#18,#67,#6E,#08,#67       ;9...gn.g
       DB       #14,#0C,#78,#18,#1F,#C7,#08,#16       ;..x..G..
       DB       #F8,#10,#34,#83,#C0,#6C,#00,#21       ;x.4.@l.!
       DB       #D8,#00,#FF,#FF,#E0,#FF,#FF,#FE       ;X...`..~
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #7F,#FF,#FF,#8F,#FF,#FF,#70,#FF       ;......p.
       DB       #FF,#8F,#0F,#FF,#78,#F7,#FF,#07       ;....xw..
       DB       #8B,#FF,#00,#7B,#FF,#FF,#FD,#FF       ;...{..}.
       DB       #02,#FF,#D8,#0E,#FF,#D8,#3F,#FF       ;..X..X?.
       DB       #D4,#3F,#FF,#EA,#00,#FF,#EA,#60       ;T?.j..j`
       DB       #FF,#EA,#5B,#FF,#F5,#40,#FF,#F5       ;.j[.u@.u
       DB       #C4,#FF,#F5,#E0,#FF,#FA,#EE,#FF       ;D.u`.zn.
       DB       #FA,#F1,#FF,#F2,#EF,#FF,#EF,#67       ;zq.ro.og
       DB       #FF,#D9,#54,#FF,#A1,#41,#FF,#40       ;.YT.!A.@
       DB       #A2,#FE,#C0,#A0,#FE,#A4,#A0,#FE       ;"~@ ~$ ~
       DB       #86,#50,#FE,#8F,#53,#FD,#07,#D2       ;.P~.S}.R
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#80,#FF,#F0,#3C,#FF       ;.....p<.
       DB       #E6,#3E,#FF,#EF,#FE,#FF,#EF,#FF       ;f>.o~.o.
       DB       #FF,#CF,#FF,#FF,#DF,#FF,#FF,#DC       ;.O.._..\
       DB       #FF,#FF,#D8,#EE,#FF,#DB,#E1,#FF       ;..Xn.[a.
       DB       #DF,#FF,#FF,#BF,#FF,#FF,#BF,#FF       ;_..?..?.
       DB       #9E,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#1F,#FF,#FF,#E0       ;.......`
       DB       #00,#0F,#FC,#01,#F0,#F8,#3E,#FE       ;..|.px>~
       DB       #FF,#C3,#FF,#1C,#FC,#1F,#07,#C0       ;.C..|..@
       DB       #0F,#04,#00,#FF,#00,#00,#98,#C0       ;.......@
       DB       #03,#00,#F0,#FF,#87,#FF,#FF,#FF       ;..p.....
       DB       #8E,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FE       ;.......~
       DB       #00,#FF,#F1,#FF,#3F,#0F,#00,#C7       ;..q.?..G
       DB       #F0,#00,#37,#00,#00,#17,#0F,#F0       ;p.7....p
       DB       #17,#FC,#00,#77,#00,#00,#77,#00       ;.|.w..w.
       DB       #00,#E7,#FF,#FF,#E7,#FF,#FF,#FB       ;.g..g..{
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FE,#00,#FF,#F9,#EE,#FF,#86,#19       ;~..yn...
       DB       #FE,#7A,#19,#FD,#8E,#19,#FA,#07       ;~z.}..z.
       DB       #9F,#F4,#1F,#9A,#F4,#3B,#96,#F4       ;.t..t;.t
       DB       #E3,#CA,#F4,#37,#C9,#F4,#17,#C6       ;cJt7It.F
       DB       #FA,#17,#C3,#FA,#0F,#E1,#FA,#07       ;z.Cz.az.
       DB       #A1,#FD,#01,#B1,#FD,#80,#B0,#FE       ;!}.1}.0~
       DB       #90,#10,#FE,#D0,#08,#FF,#50,#06       ;..~P..P.
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#7F       ;........
       DB       #FF,#FF,#BF,#00,#00,#5F,#FF,#FF       ;..?.._..
       DB       #BF,#00,#00,#7F,#FF,#FF,#FF,#FF       ;?.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #7F,#FF,#FF,#BF,#FF,#FF,#DF,#FF       ;...?.._.
       DB       #FF,#2F,#FF,#FF,#17,#FF,#FF,#17       ;./......
       DB       #FF,#FF,#17,#FF,#FF,#17,#FF,#FF       ;........
       DB       #02,#FF,#BC,#00,#FF,#AB,#C7,#FF       ;..<..+G.
       DB       #D0,#00,#FF,#E8,#00,#FF,#E8,#40       ;P..h..h@
       DB       #FF,#E8,#81,#FF,#F4,#01,#FF,#F4       ;.h..t..t
       DB       #01,#FF,#F7,#C3,#FF,#F7,#FF,#FF       ;..wC.w..
       DB       #F7,#FF,#FF,#EF,#FF,#FF,#EF,#FF       ;w..o..o.
       DB       #FF,#EE,#3F,#FF,#EC,#1F,#FF,#E8       ;.n?.l..h
       DB       #3F,#FF,#E8,#37,#FF,#E8,#52,#FF       ;?.h7.hR.
       DB       #E8,#11,#FF,#E8,#10,#FF,#E8,#10       ;h..h..h.
       DB       #01,#EF,#FF,#FF,#DF,#FF,#FF,#BF       ;.o.._..?
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #7F,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#7F,#FF,#FF,#BF,#FF,#FF,#BF       ;....?..?
       DB       #FF,#FF,#DF,#FF,#FF,#A7,#FF,#FF       ;.._..'..
       DB       #1B,#FF,#FF,#85,#FF,#FF,#42,#FF       ;......B.
       DB       #FF,#01,#7F,#FF,#00,#BF,#FF,#C0       ;.....?.@
       DB       #5F,#FF,#60,#5F,#FF,#38,#2F,#FF       ;_.`_.8/.
       DB       #80,#FF,#E8,#2F,#FF,#E8,#2F,#FF       ;..h/.h/.
       DB       #E8,#2F,#FF,#C8,#5F,#FF,#A8,#DF       ;h/.H_.(_
       DB       #FF,#58,#BF,#FE,#81,#7F,#FE,#86       ;.X?~..~.
       DB       #FF,#FD,#81,#FF,#FB,#85,#FF,#F7       ;.}..{..w
       DB       #CB,#FF,#F7,#FB,#FF,#EF,#F7,#FF       ;K.w{.ow.
       DB       #EF,#6F,#FF,#DF,#9F,#FF,#BE,#7F       ;oo._..>.
       DB       #FF,#BE,#00,#00,#BE,#00,#07,#9F       ;.>..>...
       DB       #87,#FF,#8F,#FF,#FF,#BF,#F8,#00       ;.....?x.
       DB       #81,#EC,#2F,#FF,#F2,#17,#FF,#FD       ;.l/.r..}
       DB       #17,#FF,#FA,#77,#FF,#F4,#17,#FF       ;..zw.t..
       DB       #F4,#2F,#FF,#F4,#2F,#FF,#F4,#2F       ;t/.t/.t/
       DB       #FF,#F7,#EF,#FF,#F7,#F7,#FF,#F7       ;.wo.ww.w
       DB       #F7,#FF,#F7,#F7,#FF,#FB,#CF,#FF       ;w.ww.{O.
       DB       #FB,#DF,#FF,#FB,#DF,#FF,#FB,#E7       ;{_.{_.{g
       DB       #FF,#03,#F9,#FF,#FF,#FE,#FF,#FF       ;..y..~..
       DB       #FF,#7F,#00,#00,#FF,#FF,#FF,#FF       ;........
       DB       #01,#7F,#FF,#FF,#BF,#FF,#FF,#BF       ;....?..?
       DB       #FF,#FF,#3F,#FF,#FF,#DF,#FF,#FF       ;..?.._..
       DB       #5F,#FF,#FF,#5F,#FF,#FF,#EF,#FF       ;_.._..o.
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#EF       ;.o..o..o
       DB       #FF,#FF,#EF,#FF,#FF,#F3,#FF,#FF       ;..o..s..
       DB       #0D,#FF,#FF,#82,#FF,#FF,#02,#FF       ;........
       DB       #FF,#01,#7F,#FF,#11,#7F,#FF,#11       ;........
       DB       #BF,#FF,#30,#BF,#FF,#70,#BF,#FF       ;?.0?.p?.
       DB       #80,#FF,#F6,#0B,#FF,#F6,#1B,#FF       ;..v..v..
       DB       #FA,#2B,#FF,#FA,#0B,#FF,#FA,#17       ;z+.z..z.
       DB       #FF,#FA,#17,#FF,#E2,#17,#FF,#DE       ;.z..b..^
       DB       #17,#FF,#A3,#97,#FF,#62,#EF,#FE       ;..#..bo~
       DB       #C0,#DF,#FD,#C3,#BF,#FD,#EE,#7F       ;@_}C?}n.
       DB       #F3,#FD,#FF,#EF,#FD,#FF,#EF,#E3       ;s}.o}.oc
       DB       #FF,#EF,#80,#00,#EF,#01,#FF,#EF       ;.o..o..o
       DB       #9F,#FF,#0F,#FF,#FF,#7F,#FF,#00       ;........
       DB       #81,#B0,#17,#FF,#CC,#0B,#FF,#F3       ;.0..L..s
       DB       #05,#FF,#FC,#C5,#FF,#FD,#FD,#FF       ;..|E.}}.
       DB       #FA,#0B,#FF,#FA,#0B,#FF,#FA,#17       ;z..z..z.
       DB       #FF,#F7,#AF,#FF,#EF,#EF,#FF,#EF       ;.w/.oo.o
       DB       #EF,#FF,#EF,#EF,#FF,#F7,#EF,#FF       ;o.oo.wo.
       DB       #F7,#9F,#FF,#F7,#9F,#FF,#0F,#E7       ;w..w...g
       DB       #FF,#FF,#F9,#FF,#FF,#FE,#FF,#FF       ;..y..~..
       DB       #FE,#FF,#00,#00,#FF,#FF,#FF,#FF       ;~.......
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#0F       ;........
       DB       #FF,#FC,#F3,#FF,#FB,#FD,#FF,#FB       ;.|s.{}.{
       DB       #FE,#FF,#F0,#02,#FF,#F7,#C5,#FF       ;~.p..wE.
       DB       #F7,#CD,#FF,#F7,#85,#FF,#EF,#82       ;wM.w..o.
       DB       #FF,#EF,#85,#FF,#EF,#C5,#FF,#EF       ;.o..oE.o
       DB       #BD,#FF,#DF,#93,#FF,#B1,#97,#FF       ;=._..1..
       DB       #40,#CB,#FF,#40,#05,#FE,#80,#0A       ;@K.@.~..
       DB       #A0,#FD,#80,#01,#FD,#06,#09,#FA       ; }..}..z
       DB       #0F,#81,#F6,#0C,#F3,#F4,#B8,#01       ;..v.st8.
       DB       #F4,#68,#03,#F4,#3C,#03,#F2,#1C       ;th.t<.r.
       DB       #03,#01,#0F,#B6,#E0,#CC,#D9,#FF       ;...6`LY.
       DB       #FE,#20,#0F,#FC,#21,#F0,#1F,#FF       ;~ .|!p..
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#EE       ;.o..o..n
       DB       #1F,#FF,#EC,#1F,#FF,#EC,#0F,#FF       ;..l..l..
       DB       #EC,#0F,#FF,#EC,#0D,#FF,#E8,#0B       ;l..l..h.
       DB       #01,#BF,#FF,#FF,#BF,#FF,#FF,#5F       ;.?..?.._
       DB       #FF,#FF,#5F,#FF,#FF,#AF,#FF,#FF       ;.._../..
       DB       #2F,#FF,#FF,#2F,#FF,#FF,#5F,#FF       ;/../.._.
       DB       #FF,#5F,#FF,#FF,#DF,#FF,#FF,#DF       ;._.._.._
       DB       #FF,#FF,#DF,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #EF,#FF,#FF,#F3,#FF,#FF,#8D,#FF       ;o..s....
       DB       #FF,#82,#FF,#FF,#41,#7F,#FF,#20       ;....A.. 
       DB       #BF,#FF,#00,#5F,#FF,#80,#2F,#FF       ;?.._../.
       DB       #A1,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;!.......
       DB       #FF,#07,#FF,#FE,#F9,#FF,#FD,#FE       ;...~y.}~
       DB       #FF,#FD,#FF,#FF,#F8,#01,#FF,#FB       ;.}..x..{
       DB       #E2,#FF,#FB,#E6,#FF,#FB,#E2,#FF       ;b.{f.{b.
       DB       #FB,#C1,#FF,#FB,#C2,#FF,#FB,#F2       ;{A.{B.{r
       DB       #FF,#FB,#EE,#FF,#F7,#AC,#FF,#EF       ;.{n.w,.o
       DB       #DC,#FF,#EF,#66,#FF,#EC,#21,#FF       ;\.of.l!.
       DB       #EC,#21,#FF,#E8,#11,#FF,#EC,#19       ;l!.h..l.
       DB       #02,#FF,#EC,#1F,#FF,#EC,#11,#FF       ;..l..l..
       DB       #EE,#1E,#FF,#EB,#0F,#FF,#F5,#1F       ;n..k..u.
       DB       #FF,#F5,#03,#FF,#FA,#80,#FF,#FB       ;.u..z..{
       DB       #F8,#FF,#FD,#8F,#FF,#FD,#E3,#FF       ;x.}..}c.
       DB       #FD,#FE,#FF,#FD,#FE,#FF,#FD,#FF       ;}~.}~.}.
       DB       #FF,#FD,#FF,#FF,#FE,#C3,#FF,#FE       ;.}..~C.~
       DB       #83,#FF,#FE,#81,#FF,#FE,#81,#FF       ;..~..~..
       DB       #FE,#81,#FF,#FE,#81,#FF,#FE,#81       ;~..~..~.
       DB       #A2,#DF,#FF,#FF,#DF,#FF,#FF,#EF       ;"_.._..o
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #38,#7F,#FF,#0F,#BF,#FF,#00,#40       ;8...?..@
       DB       #00,#7C,#7F,#FF,#A4,#60,#00,#BF       ;.|..$`.?
       DB       #EF,#FF,#C0,#9F,#FF,#D8,#7F,#FF       ;o.@..X..
       DB       #C6,#7F,#FF,#E1,#BF,#FF,#C8,#5F       ;F..a?.H_
       DB       #FF,#80,#2F,#FF,#C0,#17,#FF,#30       ;../.@..0
       DB       #0B,#FF,#1C,#05,#FF,#07,#05,#FF       ;........
       DB       #80,#FF,#FE,#82,#FF,#FE,#82,#FF       ;..~..~..
       DB       #FE,#85,#FF,#FE,#85,#FF,#FC,#C5       ;~..~..|E
       DB       #FF,#F3,#ED,#FF,#EC,#BB,#FF,#D0       ;.sm.l;.P
       DB       #77,#FF,#B0,#4F,#FF,#70,#DF,#FF       ;w.0O.p_.
       DB       #7F,#BF,#FE,#FF,#7F,#FC,#FE,#FF       ;.?~..|~.
       DB       #FB,#FE,#FF,#FB,#E1,#FF,#FB,#DF       ;{~.{a.{_
       DB       #FF,#FB,#C0,#00,#FB,#E0,#00,#FB       ;.{@.{`.{
       DB       #F0,#3E,#FD,#FF,#FE,#FD,#FF,#FE       ;p>}.~}.~
       DB       #81,#FF,#62,#FF,#FF,#5E,#FF,#FE       ;..b..^.~
       DB       #85,#FF,#FE,#85,#FF,#FE,#C5,#FF       ;..~..~E.
       DB       #FF,#45,#FF,#FE,#CD,#FF,#FC,#ED       ;.E.~M.|m
       DB       #FF,#FB,#FD,#FF,#FB,#FD,#FF,#FD       ;.{}.{}.}
       DB       #FD,#FF,#FB,#DD,#FF,#F7,#E3,#FF       ;}.{].wc.
       DB       #F7,#DF,#FF,#F7,#BF,#FF,#EF,#CF       ;w_.w?.oO
       DB       #FF,#0F,#F3,#FF,#FF,#FD,#FF,#FF       ;..s..}..
       DB       #FD,#FF,#00,#03,#FF,#FF,#FF,#FF       ;}.......
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#00,#0F       ;........
       DB       #FF,#FF,#F7,#FF,#00,#0F,#FF,#FF       ;..w.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #02,#FF,#FE,#00,#FF,#FC,#FE,#FF       ;..~..|~.
       DB       #FB,#81,#FF,#F6,#00,#FF,#EC,#3C       ;{..v..l<
       DB       #FF,#D0,#3F,#FF,#A0,#7F,#FF,#40       ;.P?. ..@
       DB       #FE,#FF,#41,#FC,#FF,#43,#FC,#FE       ;~.A|.C|~
       DB       #84,#EC,#FE,#82,#FB,#FE,#83,#CD       ;.l~.{~.M
       DB       #FE,#C2,#94,#FE,#C0,#0F,#FF,#61       ;~B.~@..a
       DB       #04,#FF,#53,#00,#FF,#62,#84,#FF       ;..S..b..
       DB       #A0,#40,#FF,#D0,#30,#FF,#D2,#06       ; @.P0.R.
       DB       #01,#05,#FF,#FF,#04,#7F,#FF,#C7       ;.......G
       DB       #BF,#FF,#76,#5F,#FF,#0C,#5F,#FF       ;?.v_.._.
       DB       #0F,#AF,#FF,#E2,#57,#FF,#9E,#57       ;./.bW..W
       DB       #FF,#02,#77,#FF,#82,#4F,#FF,#82       ;..w..O..
       DB       #5F,#FF,#84,#5F,#FF,#34,#5F,#FF       ;_.._.4_.
       DB       #CE,#5F,#FF,#02,#DF,#FF,#00,#EF       ;N_.._..o
       DB       #FF,#07,#6F,#FF,#5C,#77,#FF,#70       ;..o.\w.p
       DB       #77,#FF,#60,#37,#FF,#C0,#37,#FF       ;w.`7.@7.
       DB       #02,#FF,#D1,#03,#FF,#D8,#01,#FF       ;..Q..X..
       DB       #E8,#41,#FF,#E8,#01,#FF,#E8,#0E       ;hA.h..h.
       DB       #FF,#E8,#02,#FF,#D8,#02,#FF,#DF       ;.h..X.._
       DB       #87,#FF,#DF,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #DF,#FF,#FF,#DF,#FE,#FF,#DE,#7F       ;_.._~.^.
       DB       #FF,#EC,#0D,#FF,#EC,#0C,#FF,#EC       ;.l..l..l
       DB       #1E,#FF,#E8,#12,#FF,#E8,#11,#FF       ;..h..h..
       DB       #E8,#10,#FF,#E8,#10,#FF,#E8,#10       ;h..h..h.
       DB       #A4,#FF,#B7,#FF,#FF,#B7,#FF,#FF       ;$.7..7..
       DB       #B7,#FF,#FF,#B7,#FF,#FF,#B7,#FF       ;7..7..7.
       DB       #FF,#DB,#FF,#FF,#DB,#FF,#FF,#DB       ;.[..[..[
       DB       #FF,#00,#1B,#FF,#80,#0B,#FF,#C0       ;.......@
       DB       #03,#FF,#2F,#FF,#FF,#17,#FF,#FF       ;../.....
       DB       #8B,#FF,#FF,#45,#FF,#FF,#02,#FF       ;...E....
       DB       #FF,#03,#7F,#FF,#01,#7F,#FF,#80       ;........
       DB       #BF,#FF,#60,#BF,#FF,#30,#5F,#FF       ;?.`?.0_.
       DB       #02,#FF,#FF,#80,#FF,#FF,#3C,#FF       ;......<.
       DB       #FE,#FF,#FF,#FE,#FF,#FF,#FC,#00       ;~..~..|.
       DB       #FF,#FC,#F8,#FF,#FD,#FB,#FF,#FD       ;.|x.}{.}
       DB       #F9,#FF,#FD,#F0,#FF,#FD,#E1,#FF       ;y.}p.}a.
       DB       #FB,#E1,#FF,#FB,#FF,#FF,#FB,#F4       ;{a.{..{t
       DB       #FF,#F7,#EC,#FF,#EC,#3F,#FF,#E8       ;.wl.l?.h
       DB       #39,#FF,#D8,#1C,#FF,#D8,#07,#FF       ;9.X..X..
       DB       #D8,#03,#FF,#DC,#01,#FF,#EE,#00       ;X..\..n.
       DB       #01,#07,#FF,#FF,#1B,#FF,#FF,#15       ;........
       DB       #FF,#FF,#8A,#FF,#FF,#89,#7F,#FF       ;........
       DB       #84,#BF,#FF,#02,#5F,#FF,#01,#23       ;.?.._..#
       DB       #FF,#80,#9D,#FF,#00,#DC,#FF,#00       ;.....\..
       DB       #B7,#7F,#00,#85,#7F,#03,#05,#1F       ;7.......
       DB       #0E,#F9,#BF,#F8,#B7,#5F,#21,#5D       ;.y?x7_!]
       DB       #DF,#C2,#80,#3F,#05,#7F,#FF,#0E       ;_B.?....
       DB       #FF,#FF,#11,#FF,#FF,#2F,#FF,#FF       ;...../..
       DB       #02,#FF,#ED,#E0,#FF,#F5,#7F,#FF       ;..m`.u..
       DB       #F6,#01,#FF,#FB,#80,#FF,#FB,#42       ;v..{..{B
       DB       #FF,#FB,#02,#FF,#FB,#80,#FF,#FB       ;.{..{..{
       DB       #FB,#FF,#FB,#FF,#FF,#FB,#FF,#FF       ;{.{..{..
       DB       #FB,#FF,#FF,#F7,#3F,#FF,#F6,#0F       ;{..w?.v.
       DB       #FF,#F6,#0F,#FF,#F4,#0F,#FF,#F4       ;.v..t..t
       DB       #0F,#FF,#E8,#0D,#FF,#E8,#08,#FF       ;..h..h..
       DB       #D0,#18,#FF,#D0,#30,#FF,#D0,#20       ;P..P0.P 
       DB       #01,#5F,#FF,#FF,#BF,#FF,#FF,#BF       ;._..?..?
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #BF,#FF,#FF,#BF,#FF,#FF,#BF,#FF       ;?..?..?.
       DB       #FF,#DF,#FF,#FF,#5F,#FF,#FF,#AF       ;._.._../
       DB       #FF,#FF,#97,#FF,#FF,#8B,#FF,#FF       ;........
       DB       #C5,#FF,#FF,#42,#FF,#FF,#21,#7F       ;E..B..!.
       DB       #FF,#00,#BF,#FF,#80,#DF,#FF,#40       ;..?.._.@
       DB       #5F,#FF,#20,#2F,#FF,#10,#2F,#FF       ;_. /../.
       DB       #80,#FF,#D0,#5F,#FF,#D0,#5F,#FF       ;..P_.P_.
       DB       #D0,#BF,#FF,#B0,#BF,#FF,#7B,#7F       ;P?.0?.{.
       DB       #FE,#8E,#FF,#FD,#82,#FF,#FD,#05       ;~..}..}.
       DB       #FF,#FD,#05,#FF,#FD,#8D,#FF,#FD       ;.}..}..}
       DB       #D3,#FF,#FB,#EF,#FF,#FB,#EF,#FF       ;S.{o.{o.
       DB       #FB,#EF,#FF,#FC,#EF,#FF,#FB,#9F       ;{o.|o.{.
       DB       #FF,#FB,#80,#00,#F7,#80,#3F,#EF       ;.{..w.?o
       DB       #C3,#FF,#EF,#FF,#FF,#EF,#FC,#00       ;C.o..o|.
       DB       #81,#F6,#2F,#FF,#FB,#17,#FF,#FB       ;.v/.{..{
       DB       #F7,#FF,#FD,#77,#FF,#FA,#37,#FF       ;w.}w.z7.
       DB       #F4,#2F,#FF,#F4,#2F,#FF,#EC,#2F       ;t/.t/.l/
       DB       #FF,#EE,#4F,#FF,#EF,#F7,#FF,#EF       ;.nO.ow.o
       DB       #F7,#FF,#F3,#B7,#FF,#FB,#CF,#FF       ;w.s7.{O.
       DB       #FB,#DF,#FF,#FB,#DF,#FF,#F7,#CF       ;{_.{_.wO
       DB       #FF,#0F,#F3,#FF,#FF,#FD,#FF,#FF       ;..s..}..
       DB       #FE,#FF,#00,#00,#FF,#FF,#FF,#FF       ;~.......
       DB       #02,#FF,#FF,#FE,#FF,#FF,#FD,#FF       ;...~..}.
       DB       #FF,#FB,#FF,#FF,#F7,#FF,#FF,#F0       ;.{..w..p
       DB       #FF,#FF,#F7,#FF,#FF,#EF,#FF,#FF       ;..w..o..
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#DF,#FF       ;o..o.._.
       DB       #FF,#DF,#FF,#FF,#DF,#FF,#FF,#DE       ;._.._..^
       DB       #FF,#FF,#DF,#FF,#FF,#B0,#FF,#FF       ;.._..0..
       DB       #60,#FF,#FF,#40,#FF,#FE,#C2,#FF       ;`..@.~B.
       DB       #FE,#8C,#FF,#FE,#83,#FF,#FE,#87       ;~..~..~.
       DB       #A5,#1F,#FF,#FF,#E7,#FF,#FF,#FB       ;%...g..{
       DB       #FF,#FF,#FD,#FF,#FF,#05,#FF,#FF       ;..}.....
       DB       #EB,#FF,#FF,#9B,#FF,#FF,#8B,#FF       ;k.......
       DB       #FF,#85,#FF,#FF,#09,#FF,#FF,#88       ;........
       DB       #00,#1F,#F8,#01,#E0,#A0,#06,#1F       ;..x.` ..
       DB       #BE,#38,#10,#21,#C0,#F7,#1E,#03       ;>8.!@w..
       DB       #2F,#00,#1F,#DF,#00,#20,#3F,#01       ;/.._. ?.
       DB       #EF,#FF,#FF,#1F,#FF,#38,#FF,#FF       ;o....8..
       DB       #02,#FF,#FF,#66,#FF,#FF,#61,#FF       ;...f..a.
       DB       #FF,#50,#FF,#FF,#40,#FF,#FF,#40       ;.P..@..@
       DB       #FF,#FF,#40,#FF,#FF,#60,#FF,#FF       ;..@..`..
       DB       #7C,#FF,#FE,#FF,#FF,#FE,#FF,#FF       ;|.~..~..
       DB       #FE,#FF,#FF,#FE,#87,#FF,#FD,#03       ;~..~..}.
       DB       #FF,#FD,#03,#FF,#FD,#03,#FF,#FD       ;.}..}..}
       DB       #02,#FF,#FD,#04,#FF,#FB,#0C,#FF       ;..}..{..
       DB       #FA,#08,#FF,#FA,#08,#FF,#FA,#30       ;z..z..z0
       DB       #01,#29,#FF,#FF,#7B,#FF,#FF,#33       ;.)..{..3
       DB       #FF,#FF,#57,#FF,#FF,#57,#FF,#FF       ;..W..W..
       DB       #57,#FF,#FF,#27,#FF,#FF,#B7,#FF       ;W..'..7.
       DB       #FF,#F7,#FF,#FF,#F7,#FF,#FF,#FB       ;.w..w..{
       DB       #FF,#FF,#FC,#FF,#FF,#E3,#7F,#FF       ;..|..c..
       DB       #C1,#BF,#FF,#C0,#5F,#FF,#C0,#2F       ;A?.@_.@/
       DB       #FF,#C0,#17,#FF,#E0,#17,#FF,#38       ;.@..`..8
       DB       #0B,#FF,#0F,#05,#FF,#01,#05,#FF       ;........
       DB       #80,#FF,#FA,#17,#FF,#FA,#2F,#FF       ;..z..z/.
       DB       #F6,#2F,#FF,#CF,#DF,#FF,#BB,#DF       ;v/.O_.;_
       DB       #FF,#47,#BF,#FF,#41,#7F,#FE,#C1       ;.G?.A.~A
       DB       #7F,#FD,#C2,#FF,#FB,#E5,#FF,#FB       ;.}B.{e.{
       DB       #FD,#FF,#FB,#FB,#FF,#F7,#E7,#FF       ;}.{{.wg.
       DB       #F7,#EF,#FF,#EF,#1F,#FF,#DE,#FF       ;wo.o..^.
       DB       #FF,#BE,#00,#00,#BE,#00,#07,#9F       ;.>..>...
       DB       #87,#FF,#8F,#FF,#FF,#BF,#F8,#00       ;.....?x.
       DB       #81,#FF,#62,#FF,#FF,#5E,#FF,#FE       ;..b..^.~
       DB       #C5,#FF,#FE,#C5,#FF,#FE,#C5,#FF       ;E.~E.~E.
       DB       #FE,#65,#FF,#FE,#ED,#FF,#FC,#FD       ;~e.~m.|}
       DB       #FF,#FB,#FD,#FF,#FB,#FD,#FF,#F5       ;.{}.{}.u
       DB       #FD,#FF,#FB,#DD,#FF,#F7,#E3,#FF       ;}.{].wc.
       DB       #F7,#DF,#FF,#F7,#BF,#FF,#EF,#CF       ;w_.w?.oO
       DB       #FF,#0F,#F3,#FF,#FF,#FD,#FF,#FF       ;..s..}..
       DB       #FD,#FF,#00,#01,#FF,#FF,#FF,#FF       ;}.......
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#00,#00,#0F,#FF,#FF,#F7       ;.......w
       DB       #00,#00,#0F,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #A6,#FB,#E0,#2F,#F7,#F8,#57,#F7       ;&{`/wxWw
       DB       #FC,#57,#F0,#0C,#2B,#EF,#C8,#2B       ;|Wp.+oH+
       DB       #EF,#98,#15,#DF,#08,#15,#DF,#04       ;o.._.._.
       DB       #0A,#DF,#08,#0A,#BF,#08,#05,#BF       ;._..?..?
       DB       #B8,#05,#BF,#20,#07,#A2,#B0,#06       ;8.? ."0.
       DB       #20,#EE,#0C,#40,#13,#1C,#40,#6D       ; n.@..@m
       DB       #90,#40,#36,#E3,#60,#1B,#84,#A8       ;.@6c`..(
       DB       #0E,#0A,#A4,#04,#11,#B2,#04,#26       ;..$..2.&
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #BF,#FF,#FF,#5F,#FF,#FF,#DF,#FF       ;?.._.._.
       DB       #FF,#2F,#FF,#FF,#AF,#FF,#FF,#EF       ;./../..o
       DB       #FF,#FF,#C7,#FF,#FF,#F7,#FF,#FF       ;..G..w..
       DB       #A7,#DB,#80,#FD,#E8,#E3,#86,#E8       ;'[.}hc.h
       DB       #3E,#1C,#F6,#03,#30,#FA,#3F,#E0       ;>.v.0z?`
       DB       #FA,#FF,#40,#FB,#FF,#C0,#FB,#FF       ;z.@{.@{.
       DB       #C1,#FB,#FF,#C3,#FB,#87,#86,#FB       ;A{.C{..{
       DB       #83,#9D,#FB,#03,#F3,#FD,#01,#8F       ;..{.s}..
       DB       #FD,#01,#7F,#FD,#81,#7F,#FE,#81       ;}..}..~.
       DB       #7F,#FE,#81,#7F,#FF,#41,#7F,#FF       ;.~...A..
       DB       #41,#7F,#FF,#41,#7F,#FF,#41,#7F       ;A..A..A.
       DB       #03,#05,#FF,#FF,#06,#FF,#FF,#02       ;........
       DB       #FF,#FF,#3B,#7F,#FF,#71,#1F,#FF       ;..;..q..
       DB       #50,#EF,#FF,#10,#F0,#3F,#6B,#F8       ;Po..p?kx
       DB       #DF,#F7,#F0,#DF,#F9,#CD,#DF,#FD       ;_wp_yM_}
       DB       #BF,#DF,#FE,#7F,#DF,#FF,#BF,#BF       ;?_~._.??
       DB       #FF,#DF,#7F,#FF,#EE,#FF,#FF,#F6       ;._..n..v
       DB       #FF,#FF,#F9,#FF,#FF,#FF,#FF,#FF       ;..y.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #80,#FF,#A1,#7F,#FF,#A2,#7F,#FF       ;..!.."..
       DB       #A2,#FF,#FF,#62,#FF,#FE,#BE,#FF       ;"..b.~>.
       DB       #FD,#8C,#FF,#FD,#09,#FF,#FD,#0B       ;}..}..}.
       DB       #FF,#FD,#8B,#FF,#FB,#93,#FF,#F7       ;.}..{..w
       DB       #F7,#FF,#F7,#F7,#FF,#FB,#F7,#FF       ;w.ww.{w.
       DB       #FD,#F7,#FF,#FB,#C7,#FF,#FB,#CF       ;}w.{G.{O
       DB       #FF,#F7,#80,#00,#F7,#E0,#00,#F7       ;.w..w`.w
       DB       #E0,#3F,#FB,#FF,#FF,#F8,#FF,#C0       ;`?{..x.@
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#00,#00,#FF,#FF       ;........
       DB       #FE,#FF,#FF,#80,#FF,#00,#3F,#FF       ;~.....?.
       DB       #A8,#DB,#80,#6F,#E8,#E3,#BB,#E8       ;([.ohc;h
       DB       #3E,#01,#F6,#03,#FE,#FA,#3F,#83       ;>.v.~z?.
       DB       #FA,#FF,#00,#FB,#FF,#80,#FB,#FF       ;z..{..{.
       DB       #80,#FB,#FF,#80,#FB,#87,#E0,#FB       ;.{..{.`{
       DB       #83,#BF,#FB,#03,#00,#FD,#01,#7F       ;.?{..}..
       DB       #FD,#01,#7F,#FD,#81,#7F,#FE,#81       ;}..}..~.
       DB       #7F,#FE,#81,#7F,#FF,#41,#7F,#FF       ;.~...A..
       DB       #41,#7F,#FF,#41,#7F,#FF,#41,#7F       ;A..A..A.
       DB       #A9,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;).......
       DB       #FF,#F0,#00,#00,#06,#F8,#00,#06       ;.p...x..
       DB       #07,#83,#8E,#00,#7F,#8E,#00,#07       ;........
       DB       #FE,#1C,#07,#7E,#F6,#0F,#7E,#01       ;~..~v.~.
       DB       #F7,#7E,#FC,#07,#1C,#FF,#F8,#03       ;w~|...x.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#00,#00,#00,#FF       ;........
       DB       #FF,#FE,#FF,#E0,#00,#00,#1F,#FF       ;.~.`....
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#07,#FF,#FC,#FB,#FF       ;.....|{.
       DB       #FB,#F5,#FF,#FB,#CC,#FF,#F7,#33       ;{u.{L.w3
       DB       #7F,#F6,#E1,#7F,#F7,#E0,#BF,#FB       ;.va.w`?{
       DB       #F0,#BF,#FB,#FB,#7F,#FB,#FA,#7F       ;p?{{.{z.
       DB       #F7,#1B,#BF,#EC,#00,#5F,#E8,#00       ;w.?l._h.
       DB       #2F,#D8,#20,#17,#D0,#30,#0B,#B0       ;/X .P0.0
       DB       #3C,#0D,#A0,#4F,#19,#A0,#F8,#EE       ;<. O. xn
       DB       #02,#FF,#FF,#A4,#FF,#FF,#D2,#FF       ;...$..R.
       DB       #FF,#E9,#FF,#FF,#F4,#FF,#FF,#FA       ;.i..t..z
       DB       #FF,#FF,#FD,#FF,#FF,#FE,#FF,#FF       ;..}..~..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#00,#00,#FE       ;.......~
       DB       #FF,#FF,#FF,#03,#FF,#FF,#F0,#00       ;......p.
       DB       #AA,#63,#20,#02,#84,#18,#02,#9C       ;*c .....
       DB       #08,#01,#84,#06,#01,#82,#01,#83       ;........
       DB       #42,#00,#FF,#A1,#00,#FF,#D8,#C0       ;B..!..X@
       DB       #FF,#EE,#20,#FF,#F3,#10,#F9,#FA       ;.n .s.yz
       DB       #1C,#F0,#FB,#38,#E0,#FD,#E8,#60       ;.p{8`}h`
       DB       #FE,#E4,#60,#FE,#92,#20,#FE,#A9       ;~d`~. ~)
       DB       #10,#FF,#74,#88,#FF,#FA,#44,#FF       ;..t..zD.
       DB       #FD,#22,#FF,#FE,#91,#FF,#FF,#48       ;}".~...H
       DB       #01,#FD,#FF,#FF,#82,#FF,#FF,#DA       ;.}.....Z
       DB       #FF,#FF,#55,#FF,#FF,#23,#FF,#FF       ;..U..#..
       DB       #9F,#FF,#FF,#BF,#FF,#FF,#DF,#FF       ;...?.._.
       DB       #FF,#DF,#FF,#FF,#EF,#FF,#FF,#F7       ;._..o..w
       DB       #FF,#FF,#CB,#FF,#FF,#65,#FF,#FF       ;..K..e..
       DB       #25,#FF,#FF,#22,#FF,#FF,#12,#FF       ;%.."....
       DB       #FF,#13,#7F,#FF,#09,#7F,#FF,#09       ;........
       DB       #BF,#FF,#0C,#BF,#FF,#CC,#DF,#FF       ;?..?.L_.
       DB       #02,#FF,#FF,#A4,#FF,#FF,#D2,#FF       ;...$..R.
       DB       #FF,#E9,#FF,#FF,#F4,#FF,#FF,#FA       ;.i..t..z
       DB       #FF,#FF,#FD,#FF,#FF,#F3,#FF,#FF       ;..}..s..
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#EF,#FF       ;o..o..o.
       DB       #FF,#DF,#FF,#FF,#3F,#FF,#FE,#FF       ;._..?.~.
       DB       #FF,#FE,#FF,#FF,#FE,#FF,#FF,#FF       ;.~..~...
       DB       #0F,#FF,#FC,#00,#FF,#03,#FF,#FE       ;..|....~
       DB       #FF,#FF,#FF,#00,#FF,#FF,#FF,#00       ;........
       DB       #01,#FE,#DF,#FF,#F7,#DF,#FF,#4C       ;.~_.w_.L
       DB       #BF,#FF,#85,#BF,#FF,#47,#7F,#FF       ;?..?.G..
       DB       #47,#7F,#FF,#A6,#FF,#FF,#BD,#FF       ;G..&..=.
       DB       #FF,#FD,#FF,#FF,#FD,#FF,#FF,#FB       ;.}..}..{
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #F7,#FF,#FF,#F7,#FF,#FF,#FB,#FF       ;w..w..{.
       DB       #FF,#FB,#FF,#FF,#FD,#FF,#FF,#FE       ;.{..}..~
       DB       #FF,#FF,#01,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FE,#FF,#FF,#FD       ;....~..}
       DB       #FF,#FF,#FB,#FF,#FF,#F4,#FF,#FF       ;..{..t..
       DB       #E8,#FF,#FF,#E8,#FF,#FF,#D0,#FF       ;h..h..P.
       DB       #FF,#A0,#FF,#FF,#41,#FF,#FE,#87       ;. ..A.~.
       DB       #AB,#F8,#7F,#FF,#E7,#9F,#FF,#DF       ;+x..g.._
       DB       #EF,#FF,#BF,#F7,#FF,#80,#37,#FF       ;o.?w..7.
       DB       #BF,#AF,#FF,#7C,#6F,#FF,#7C,#2F       ;?/.|o.|/
       DB       #FF,#7E,#17,#FF,#7E,#2F,#FF,#FE       ;.~..~/.~
       DB       #2F,#FF,#FD,#EF,#FF,#F9,#1F,#FF       ;/.}o.y..
       DB       #1B,#7F,#FF,#08,#BF,#FF,#00,#5F       ;....?.._
       DB       #FF,#10,#2F,#FF,#30,#0F,#FF,#78       ;../.0..x
       DB       #17,#FF,#E4,#17,#FF,#F3,#D7,#FF       ;..d..sW.
       DB       #02,#FF,#FE,#87,#FF,#FF,#42,#FF       ;..~...B.
       DB       #FF,#A1,#FF,#FF,#D1,#FF,#FF,#AC       ;.!..Q..,
       DB       #FF,#FF,#A2,#FF,#FF,#D2,#FF,#FF       ;.."..R..
       DB       #D6,#FF,#FF,#E7,#FF,#FF,#F8,#FF       ;V..g..x.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #AC,#88,#37,#FF,#C0,#28,#3F,#50       ;,.7.@(?P
       DB       #28,#DF,#48,#27,#2F,#60,#7F,#F7       ;(_H'/`.w
       DB       #78,#60,#0F,#1F,#6F,#FF,#3F,#E7       ;x`..o.?g
       DB       #FF,#21,#F8,#FF,#BE,#1F,#0F,#7F       ;.!x.>...
       DB       #E0,#F1,#7F,#FE,#0E,#31,#FF,#E1       ;`q.~.1.a
       DB       #30,#64,#1E,#A0,#62,#E1,#B0,#21       ;0d. ba0!
       DB       #7F,#D0,#20,#BF,#D0,#20,#BF,#D8       ;.P ?P ?X
       DB       #30,#5F,#E8,#10,#5F,#E8,#18,#2F       ;0_h._h./
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FE,#FF,#FF,#F9,#FF,#FF       ;..~..y..
       DB       #F7,#FF,#FF,#EF,#FF,#FF,#EF,#FF       ;w..o..o.
       DB       #FF,#EF,#FF,#FF,#DF,#FF,#FF,#9F       ;.o.._...
       DB       #FF,#FF,#7F,#FF,#FF,#78,#FF,#FE       ;.....x.~
       DB       #F8,#FF,#FE,#F0,#FF,#FE,#F8,#FF       ;x.~p.~x.
       DB       #FE,#FF,#FF,#FE,#FF,#FF,#FE,#00       ;~..~..~.
       DB       #AD,#F4,#18,#2F,#F4,#14,#17,#F4       ;-t./t..t
       DB       #14,#17,#8C,#12,#17,#74,#36,#17       ;.....t6.
       DB       #80,#28,#EF,#08,#70,#5F,#0F,#E0       ;.(o.p_.`
       DB       #BF,#06,#60,#BF,#08,#F1,#7F,#F0       ;?.`?.q.p
       DB       #FE,#FF,#C1,#FE,#FF,#81,#FE,#FF       ;~.A~..~.
       DB       #00,#7E,#FF,#FE,#F9,#FF,#FD,#F7       ;.~.~y.}w
       DB       #FF,#FD,#F8,#FF,#03,#FF,#7F,#FF       ;.}x.....
       DB       #FF,#BF,#F0,#00,#3F,#0F,#FF,#FF       ;.?p.?...
       DB       #02,#FF,#FF,#FC,#FF,#FF,#FD,#FF       ;...|..}.
       DB       #FF,#FB,#FF,#FF,#F8,#FF,#FF,#FB       ;.{..x..{
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #F7,#FF,#FF,#F7,#FF,#FF,#EF,#FF       ;w..w..o.
       DB       #FF,#EF,#FF,#FF,#EB,#FF,#FF,#E9       ;.o..k..i
       DB       #FF,#FF,#D0,#FF,#FF,#A0,#FF,#FF       ;..P.. ..
       DB       #A0,#FF,#FF,#A1,#FF,#FF,#A0,#FF       ; ..!.. .
       DB       #FF,#A0,#FF,#FF,#A1,#FF,#FF,#A0       ;. ..!.. 
       DB       #01,#F8,#0A,#FF,#FE,#0D,#7F,#FF       ;.x..~...
       DB       #05,#7F,#03,#07,#BF,#E2,#0C,#5F       ;....?b._
       DB       #E6,#04,#5F,#E2,#03,#EF,#C1,#03       ;f._b.oA.
       DB       #37,#C2,#06,#17,#E2,#06,#17,#BE       ;7B..b..>
       DB       #0D,#F7,#D0,#31,#F7,#7F,#C1,#B7       ;.wP1w.A7
       DB       #01,#C3,#87,#00,#07,#7F,#00,#3E       ;.C.....>
       DB       #FF,#80,#ED,#FF,#FB,#7B,#FF,#3F       ;..m.{{.?
       DB       #C7,#FF,#06,#3F,#FF,#C5,#FF,#FF       ;G..?.E..
       DB       #02,#FF,#FF,#40,#FF,#FF,#40,#FF       ;...@..@.
       DB       #FF,#50,#FF,#FF,#42,#FF,#FF,#41       ;.P..B..A
       DB       #FF,#FF,#40,#FF,#FF,#60,#FF,#FF       ;..@..`..
       DB       #7E,#FF,#FE,#FF,#FF,#FE,#FF,#FF       ;~.~..~..
       DB       #FE,#FF,#FF,#FE,#87,#FF,#FD,#03       ;~..~..}.
       DB       #FF,#FD,#03,#FF,#FD,#03,#FF,#FD       ;.}..}..}
       DB       #02,#FF,#FD,#02,#FF,#FB,#04,#FF       ;..}..{..
       DB       #FA,#04,#FF,#FA,#08,#FF,#FA,#10       ;z..z..z.
       DB       #01,#1B,#FF,#FF,#17,#FF,#FF,#17       ;........
       DB       #FF,#FF,#37,#FF,#FF,#2F,#FF,#FF       ;..7../..
       DB       #2F,#FF,#FF,#6F,#FF,#FF,#EF,#FF       ;/..o..o.
       DB       #FF,#F7,#FF,#FF,#F7,#FF,#FF,#F7       ;.w..w..w
       DB       #FF,#FF,#DB,#FF,#FF,#CB,#FF,#FF       ;..[..K..
       DB       #C5,#FF,#FF,#C2,#FF,#FF,#A1,#7F       ;E..B..!.
       DB       #FF,#00,#BF,#FF,#80,#DF,#FF,#40       ;..?.._.@
       DB       #5F,#FF,#20,#2F,#FF,#10,#2F,#FF       ;_. /../.
       DB       #80,#FF,#FA,#17,#FF,#FA,#2F,#FF       ;..z..z/.
       DB       #F6,#2F,#FF,#CC,#5F,#FF,#BA,#DF       ;v/.L_.:_
       DB       #FF,#47,#BF,#FF,#41,#7F,#FE,#C1       ;.G?.A.~A
       DB       #7F,#FD,#C2,#FF,#FB,#E5,#FF,#FB       ;.}B.{e.{
       DB       #FD,#FF,#FB,#FB,#FF,#F7,#E7,#FF       ;}.{{.wg.
       DB       #F7,#EF,#FF,#EF,#1F,#FF,#DE,#FF       ;wo.o..^.
       DB       #FF,#BE,#00,#00,#BE,#00,#07,#9F       ;.>..>...
       DB       #87,#FF,#8F,#FF,#FF,#BF,#F8,#00       ;.....?x.
       DB       #81,#F4,#2F,#FF,#FB,#17,#FF,#FB       ;.t/.{..{
       DB       #97,#FF,#FA,#77,#FF,#F4,#37,#FF       ;..zw.t7.
       DB       #EC,#2F,#FF,#E8,#2F,#FF,#E8,#2F       ;l/.h/.h/
       DB       #FF,#EE,#6F,#FF,#EF,#EF,#FF,#EF       ;.no.oo.o
       DB       #EF,#FF,#F7,#EF,#FF,#F7,#DF,#FF       ;o.wo.w_.
       DB       #F7,#BF,#FF,#F7,#BF,#FF,#F7,#CF       ;w?.w?.wO
       DB       #FF,#0F,#F3,#FF,#FF,#FD,#FF,#FF       ;..s..}..
       DB       #FE,#FF,#00,#01,#FF,#FF,#FF,#FF       ;~.......
       DB       #02,#FF,#FF,#FC,#FF,#FF,#FD,#FF       ;...|..}.
       DB       #FF,#FB,#FF,#FF,#F8,#FF,#FF,#FB       ;.{..x..{
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #F7,#FF,#FF,#F7,#FF,#FF,#F7,#FF       ;w..w..w.
       DB       #FF,#EF,#FF,#FF,#EF,#FF,#FF,#EE       ;.o..o..n
       DB       #FF,#FF,#D0,#FF,#FF,#D0,#FF,#FF       ;..P..P..
       DB       #A0,#FF,#FF,#A2,#FF,#FF,#A3,#FF       ; .."..#.
       DB       #FF,#41,#FF,#FF,#40,#FF,#FF,#40       ;.A..@..@
       DB       #AE,#F9,#FF,#FF,#FE,#FF,#FF,#FF       ;.y..~...
       DB       #7F,#FF,#03,#7F,#FF,#E2,#FF,#FF       ;.....b..
       DB       #E6,#FF,#FF,#E2,#FF,#FF,#C1,#7F       ;f..b..A.
       DB       #FF,#C2,#FF,#FF,#E2,#FF,#FF,#BE       ;.B..b..>
       DB       #FF,#FF,#D0,#FF,#FF,#FC,#FF,#FF       ;..P..|..
       DB       #1F,#00,#00,#0F,#40,#01,#03,#30       ;....@..0
       DB       #01,#01,#CC,#0D,#80,#E3,#F2,#80       ;..L..cr.
       DB       #3F,#E1,#B0,#20,#F9,#7E,#00,#0E       ;?a0 y~..
       DB       #01,#8B,#FF,#8B,#78,#00,#FB,#10       ;....x.{.
       DB       #00,#07,#37,#FF,#FF,#2F,#FF,#FF       ;..7../..
       DB       #2F,#FF,#FF,#6F,#FF,#FF,#EF,#FF       ;/..o..o.
       DB       #FF,#F7,#FF,#FF,#F7,#FF,#FF,#F7       ;.w..w..w
       DB       #FF,#FF,#DB,#FF,#FF,#CB,#FF,#FF       ;..[..K..
       DB       #C5,#FF,#FF,#C2,#FF,#FF,#A1,#7F       ;E..B..!.
       DB       #FF,#00,#BF,#FF,#80,#DF,#FF,#40       ;..?.._.@
       DB       #5F,#FF,#20,#2F,#FF,#10,#2F,#FF       ;_. /../.
       DB       #02,#FF,#FF,#8E,#FF,#FE,#71,#FF       ;.....~q.
       DB       #FD,#D9,#FF,#FD,#0F,#FF,#FB,#03       ;}Y.}..{.
       DB       #FF,#F5,#93,#FF,#FB,#F1,#FF,#F4       ;.u..{q.t
       DB       #F8,#FF,#E9,#E8,#FF,#D3,#E8,#FF       ;x.ih.Sh.
       DB       #A7,#EC,#FF,#4F,#FC,#FE,#97,#88       ;'l.O|~..
       DB       #FD,#27,#FF,#FA,#48,#18,#F4,#90       ;}'.zH.t.
       DB       #00,#E9,#10,#00,#D2,#10,#00,#24       ;.i..R..$
       DB       #10,#03,#48,#10,#FF,#70,#10,#81       ;..H..p..
       DB       #01,#FF,#FF,#FF,#FF,#FF,#FF,#7F       ;........
       DB       #FF,#FF,#BF,#FF,#FF,#DF,#FF,#FF       ;..?.._..
       DB       #6F,#FF,#FF,#37,#FF,#FF,#97,#FF       ;o..7....
       DB       #FF,#DB,#FF,#FF,#4D,#FF,#FF,#45       ;.[..M..E
       DB       #FF,#FF,#22,#FF,#FF,#22,#FF,#FF       ;..".."..
       DB       #22,#FF,#FF,#2E,#FF,#FF,#7D,#FF       ;".....}.
       DB       #FF,#FB,#FF,#FF,#F7,#FF,#FF,#EF       ;.{..w..o
       DB       #FF,#FF,#DF,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #01,#BF,#FF,#FF,#BF,#FF,#FF,#BF       ;.?..?..?
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #BF,#FF,#FF,#BF,#FF,#FF,#7F,#FF       ;?..?....
       DB       #FF,#7F,#FF,#FF,#7F,#FF,#FF,#BF       ;.......?
       DB       #FF,#FF,#CF,#FF,#FF,#B7,#FF,#FF       ;..O..7..
       DB       #0B,#FF,#FF,#05,#FF,#FF,#82,#FF       ;........
       DB       #FF,#41,#7F,#FF,#01,#BF,#FF,#00       ;.A...?..
       DB       #DF,#FF,#80,#2F,#FF,#E0,#17,#FF       ;_../.`..
       DB       #AF,#FF,#E7,#FF,#FF,#DB,#FF,#FF       ;/.g..[..
       DB       #AB,#FF,#FF,#4B,#FF,#FE,#97,#FF       ;+..K.~..
       DB       #FD,#2F,#FF,#FA,#5F,#FF,#F4,#BF       ;}/.z_.t?
       DB       #FF,#E9,#7F,#FF,#D2,#FF,#FF,#A5       ;.i..R..%
       DB       #FF,#FF,#4B,#FF,#FF,#97,#FF,#FF       ;..K.....
       DB       #2F,#FF,#FF,#5F,#FF,#FF,#BF,#FF       ;/.._..?.
       DB       #FF,#7F,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #B0,#7F,#FF,#FF,#BF,#FF,#FF,#5F       ;0...?.._
       DB       #FF,#FF,#2F,#FF,#FF,#97,#FF,#FF       ;../.....
       DB       #4B,#FF,#FF,#A5,#FF,#FF,#D2,#FF       ;K..%..R.
       DB       #FF,#E9,#7F,#FF,#F5,#7F,#FF,#FB       ;.i..u..{
       DB       #7F,#FF,#FC,#FF,#FF,#FF,#FF,#FF       ;..|.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #B1,#BA,#DF,#FF,#4B,#67,#FF,#63       ;1:_.Kg.c
       DB       #9B,#FF,#A1,#FD,#FF,#60,#FD,#FF       ;..!}.`}.
       DB       #38,#F9,#FF,#97,#FA,#0F,#77,#EB       ;8y..z.wk
       DB       #F7,#83,#DB,#EF,#FB,#BC,#9F,#FA       ;w.[o{<.z
       DB       #7F,#EF,#FC,#3F,#DF,#FF,#BF,#BF       ;.o|?_.??
       DB       #FF,#BE,#7F,#FF,#D9,#FF,#FF,#E7       ;.>..Y..g
       DB       #FF,#FF,#FF,#FF,#01,#FF,#FF,#FE       ;.......~
       DB       #00,#1F,#FF,#FF,#EF,#00,#00,#00       ;....o...
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FE       ;.......~
       DB       #FF,#FF,#FD,#FF,#FF,#FA,#FF,#FF       ;..}..z..
       DB       #FA,#FF,#FF,#F4,#FF,#FF,#F4,#FF       ;z..t..t.
       DB       #FF,#F4,#FF,#FF,#F4,#FF,#FF,#FB       ;.t..t..{
       DB       #B2,#FF,#ED,#FF,#FF,#EC,#0F,#FF       ;2.m..l..
       DB       #ED,#F7,#FF,#EF,#FB,#FF,#DF,#FD       ;mw.o{._}
       DB       #FF,#97,#FD,#FF,#77,#BD,#F0,#77       ;..}.w=pw
       DB       #8D,#EF,#F7,#0D,#D0,#F6,#1B,#A0       ;.ow.Pv. 
       DB       #76,#17,#40,#37,#B7,#80,#36,#CF       ;v.@77.6O
       DB       #01,#37,#3F,#07,#36,#BF,#0F,#36       ;.7?.6?.6
       DB       #5F,#1B,#26,#5F,#39,#BB,#5F,#7C       ;_.&_9;_|
       DB       #E5,#5F,#1E,#7F,#5F,#07,#F1,#DF       ;e_.._.q_
       DB       #02,#FF,#FF,#FB,#FF,#FF,#FC,#FF       ;...{..|.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FE,#FF,#FF,#FD,#FF,#FF,#FD,#FF       ;~..}..}.
       DB       #FF,#FB,#FF,#FF,#FA,#FF,#FF,#FA       ;.{..z..z
       DB       #FF,#FF,#F6,#FF,#FF,#F4,#FF,#FF       ;..v..t..
       DB       #F4,#FF,#FF,#F4,#FF,#FF,#EC,#FF       ;t..t..l.
       DB       #FF,#E8,#FF,#FF,#E8,#FF,#FF,#E8       ;.h..h..h
       DB       #01,#80,#31,#5F,#F0,#7F,#DF,#5F       ;..1_p.__
       DB       #F1,#DF,#40,#F1,#BF,#60,#69,#BF       ;q_@q?`i?
       DB       #FC,#EF,#7F,#FF,#E0,#FF,#FF,#F7       ;|o..`..w
       DB       #FF,#FF,#F7,#FF,#8F,#9B,#FF,#0F       ;..w.....
       DB       #8B,#FF,#0F,#8D,#FF,#17,#C5,#FF       ;......E.
       DB       #06,#46,#FF,#07,#22,#FF,#0F,#02       ;.F.."...
       DB       #FF,#19,#01,#7F,#10,#81,#7F,#30       ;.......0
       DB       #81,#7F,#60,#41,#7F,#40,#41,#7F       ;..`A.@A.
       DB       #B3,#FF,#FF,#D8,#FF,#FF,#B0,#FF       ;3..X..0.
       DB       #FF,#B1,#FF,#FF,#6F,#FF,#FE,#CE       ;.1..o.~N
       DB       #FF,#FE,#85,#FF,#FD,#05,#FF,#FD       ;.~..}..}
       DB       #0B,#FF,#FD,#17,#FF,#FB,#B7,#FF       ;..}..{7.
       DB       #FB,#F7,#FF,#FB,#F7,#FF,#FB,#F7       ;{w.{w.{w
       DB       #FF,#FD,#EF,#FF,#FD,#EF,#FF,#FD       ;.}o.}o.}
       DB       #DF,#FF,#FB,#DF,#FF,#F7,#C0,#FF       ;_.{_.w@.
       DB       #EF,#E7,#FF,#EF,#FF,#FF,#F3,#80       ;og.o..s.
       DB       #B4,#C0,#20,#BF,#80,#38,#BF,#80       ;4@ ?.8?.
       DB       #1F,#DF,#00,#13,#DF,#FF,#90,#BF       ;._.._..?
       DB       #FF,#B8,#BF,#FF,#A1,#7F,#FF,#A1       ;.8?.!..!
       DB       #7F,#FF,#B1,#7F,#FF,#7B,#7F,#FE       ;..1..{.~
       DB       #FF,#7F,#FE,#FF,#7F,#FF,#3F,#7F       ;..~...?.
       DB       #FF,#BE,#FF,#FF,#DE,#FF,#FF,#DF       ;.>..^.._
       DB       #7F,#00,#3F,#8F,#3F,#FF,#F7,#FF       ;..?.?.w.
       DB       #FF,#FB,#E0,#00,#03,#1F,#FF,#FF       ;.{`.....
       DB       #02,#FF,#FF,#F0,#FF,#FF,#E7,#FF       ;...p..g.
       DB       #FF,#D8,#FF,#FF,#B0,#FF,#FF,#40       ;.X..0..@
       DB       #FF,#FE,#80,#FF,#FD,#00,#FF,#FD       ;.~..}..}
       DB       #04,#FF,#FA,#0C,#FF,#FA,#1C,#FF       ;..z..z..
       DB       #FA,#38,#FF,#FA,#0B,#FF,#FD,#07       ;z8.z..}.
       DB       #FF,#FE,#83,#FF,#FF,#60,#FF,#FF       ;.~...`..
       DB       #B8,#FF,#FF,#BE,#FF,#FF,#46,#FF       ;8..>..F.
       DB       #FE,#82,#FF,#FE,#81,#FF,#FD,#01       ;~..~..}.
       DB       #01,#5E,#5F,#FF,#FC,#5F,#FF,#FC       ;.^_.|_.|
       DB       #DF,#FF,#79,#EF,#FF,#79,#EF,#FF       ;_.yo.yo.
       DB       #33,#EF,#FF,#23,#F7,#FF,#27,#CB       ;3o.#w.'K
       DB       #FF,#4F,#0B,#FF,#CE,#05,#FF,#90       ;.O..N...
       DB       #05,#FF,#10,#85,#FF,#33,#85,#FF       ;.....3..
       DB       #76,#2B,#FF,#BE,#17,#FF,#3E,#2F       ;v+.>..>/
       DB       #FF,#20,#2F,#FF,#F0,#DF,#FF,#FF       ;. /.p_..
       DB       #BF,#FF,#F8,#BF,#FF,#E0,#5F,#FF       ;?.x?.`_.
       DB       #80,#FF,#FD,#02,#FF,#FA,#02,#FF       ;..}..z..
       DB       #FA,#05,#FF,#F6,#0B,#FF,#F4,#17       ;z..v..t.
       DB       #FF,#CE,#6F,#FF,#B7,#9F,#FF,#43       ;.No.7..C
       DB       #7F,#FE,#83,#7F,#FE,#82,#FF,#FD       ;.~..~..}
       DB       #C5,#FF,#FD,#FD,#FF,#FD,#FD,#FF       ;E.}}.}}.
       DB       #FE,#FB,#FF,#FD,#FB,#FF,#FB,#E7       ;~{.}{.{g
       DB       #FF,#FB,#80,#00,#F7,#80,#3F,#EF       ;.{..w.?o
       DB       #C3,#FF,#EF,#FF,#FF,#F3,#F0,#00       ;C.o..sp.
       DB       #01,#70,#6F,#FF,#70,#2F,#FF,#F0       ;.po.p/.p
       DB       #17,#FF,#F8,#17,#FF,#F8,#17,#FF       ;..x..x..
       DB       #EE,#17,#FF,#E2,#17,#FF,#41,#E7       ;n..b..Ag
       DB       #FF,#00,#0F,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#00,#7F,#FF,#FF,#BF,#FF,#FE       ;.....?.~
       DB       #7F,#FF,#00,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #02,#FF,#FF,#FF,#FF,#FF,#FE,#FF       ;......~.
       DB       #FF,#FD,#FF,#FC,#02,#FF,#E3,#FE       ;.}.|..c~
       DB       #FF,#DC,#3C,#FF,#A0,#04,#FE,#40       ;.\<. .~@
       DB       #0C,#FD,#C0,#0C,#FB,#E0,#18,#FB       ;.}@.{`.{
       DB       #F8,#29,#FD,#FF,#E9,#FE,#1F,#EC       ;x)}.i~.l
       DB       #FF,#30,#17,#FF,#40,#11,#F8,#80       ;.0..@.x.
       DB       #08,#F7,#A0,#08,#EF,#D8,#0E,#EF       ;.w .oX.o
       DB       #FF,#9F,#E7,#FF,#FD,#EF,#FF,#FF       ;..g.}o..
       DB       #01,#00,#1F,#FF,#FF,#EF,#FF,#80       ;.....o..
       DB       #17,#FF,#00,#0B,#FF,#40,#0B,#FF       ;.....@..
       DB       #7E,#3D,#FF,#FF,#FD,#FF,#E7,#FE       ;~=..}.g~
       DB       #FF,#E7,#BE,#3F,#EA,#3F,#DF,#00       ;.g>?j?_.
       DB       #00,#2F,#00,#00,#2F,#7F,#BF,#DF       ;./../.?_
       DB       #EF,#FF,#EF,#E7,#FF,#1F,#FE,#1F       ;o.og..~.
       DB       #DF,#C0,#07,#EF,#00,#04,#0F,#00       ;_@.o....
       DB       #1D,#FF,#FF,#FC,#7F,#FF,#FF,#7F       ;...|....
       DB       #03,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FC,#00,#3F,#FB,#81       ;...|.?{.
       DB       #DF,#F4,#42,#2F,#EC,#66,#37,#E8       ;_tB/lf7h
       DB       #24,#17,#E8,#3C,#17,#D0,#3C,#0B       ;$.h<.P<.
       DB       #B5,#D0,#E3,#0B,#D3,#C3,#CB,#D7       ;5Pc.SCKW
       DB       #58,#7B,#DC,#42,#1B,#B8,#E7,#0D       ;X{\B.8g.
       DB       #61,#E7,#C2,#43,#26,#63,#86,#26       ;agBC&c.&
       DB       #39,#BD,#E7,#D1,#8F,#E7,#F1,#8F       ;9=gQ.gq.
       DB       #24,#E1,#86,#E7,#61,#87,#81,#E1       ;$a.ga..a
       DB       #43,#65,#E1,#43,#E6,#E1,#45,#E7       ;CeaCfaEg
       DB       #F1,#20,#E7,#F3,#20,#E7,#E2,#1E       ;q gs gb.
       DB       #E7,#EE,#7F,#E7,#FE,#FF,#FF,#FF       ;gn.g~...
       DB       #02,#FF,#F8,#00,#FF,#F7,#FF,#FF       ;..x..w..
       DB       #E8,#01,#FF,#D0,#00,#FF,#D0,#02       ;h..P..P.
       DB       #FF,#BC,#7E,#FF,#BF,#FF,#FF,#7F       ;.<~.?...
       DB       #E7,#FC,#7D,#E7,#FB,#FC,#57,#F4       ;g|}g{|Wt
       DB       #00,#00,#F4,#00,#00,#F3,#FD,#FE       ;..t..s}~
       DB       #F7,#FF,#F7,#F0,#FF,#E7,#F3,#F8       ;w.wp.gsx
       DB       #7F,#F7,#E0,#03,#F0,#20,#00,#FF       ;.w`.p ..
       DB       #B8,#00,#FF,#3F,#FF,#FE,#FF,#FF       ;8..?.~..
       DB       #01,#FF,#FF,#FF,#7F,#FF,#FF,#BF       ;.......?
       DB       #FF,#FF,#40,#3F,#FF,#7F,#C7,#FF       ;..@?..G.
       DB       #60,#3B,#FF,#20,#05,#FF,#30,#02       ;`;. ..0.
       DB       #7F,#38,#03,#BF,#18,#07,#DF,#94       ;.8.?.._.
       DB       #1F,#DF,#97,#FF,#BF,#37,#F8,#7F       ;._..?7x.
       DB       #E8,#0D,#FF,#88,#02,#FF,#10,#01       ;h.......
       DB       #1F,#10,#05,#EF,#70,#1B,#F7,#F9       ;...op.wy
       DB       #FF,#F7,#BF,#FF,#E7,#FF,#FF,#F7       ;.w?.g..w
L_F080
       DB       #B6,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;6.......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #E7,#FF,#FF,#DB,#FF,#FF,#84,#FF       ;g..[....
       DB       #FE,#67,#3F,#FD,#E7,#DF,#E3,#E7       ;~g?}g_cg
       DB       #E3,#DF,#E7,#FD,#A3,#E7,#E2,#41       ;c_g}#gbA
       DB       #E7,#C3,#41,#E7,#C1,#41,#E7,#81       ;gCAgAAg.
       DB       #00,#8B,#81,#D1,#87,#C3,#E1,#86       ;...Q.Ca.
       DB       #E6,#61,#86,#64,#E1,#87,#67,#B9       ;fa.da.g9
       DB       #85,#E7,#E1,#9F,#C1,#81,#83,#98       ;.ga.A...
       DB       #02,#60,#80,#3D,#98,#63,#FD,#DF       ;.`.=.c}_
       DB       #1F,#CD,#D0,#F8,#0D,#D0,#18,#0B       ;.MPx.P..
       DB       #D0,#18,#0B,#D0,#1C,#0B,#D0,#3C       ;P..P..P<
;L_F0F0
       DB       #0B       ;.
;L_F0F1
       DB       #E8,#3C,#17,#E8,#24,#17,#C8,#3C       ;h<.h$.H<
       DB       #17,#3C,#3C,#39,#FF,#FF,#FE,#02       ;.<<9..~.
       DB       #FF,#FA,#7A,#FF,#FA,#3F,#FF,#FB       ;.zz.z?.{
       DB       #3F,#FF,#F7,#9E,#FF,#F7,#9E,#FF       ;?.w..w..
       DB       #F7,#CC,#FF,#EF,#C4,#FF,#D3,#E4       ;wL.oD.Sd
       DB       #FF,#D0,#F2,#FF,#A0,#73,#FF,#A0       ;.Pr. s. 
       DB       #09,#FF,#A1,#08,#FF,#A1,#CC,#FF       ;..!..!L.
       DB       #D4,#6E,#FF,#E8,#7D,#FF,#F4,#7C       ;Tn.h}.t|
       DB       #FF,#F4,#04,#FF,#FB,#0F,#FF,#FD       ;.t..{..}
       DB       #FF,#FF,#FD,#1F,#FF,#FA,#07,#01       ;..}..z..
       DB       #1F,#FF,#FF,#E7,#FF,#FF,#1B,#FF       ;...g....
       DB       #FF,#0D,#FF,#FF,#02,#FF,#FF,#01       ;........
       DB       #7F,#FF,#00,#BF,#FF,#20,#BF,#FF       ;...?. ?.
       DB       #30,#5F,#FF,#38,#5F,#FF,#1C,#5F       ;0_.8_.._
       DB       #FF,#D0,#5F,#FF,#E0,#BF,#FF,#C1       ;.P_.`?.A
       DB       #7F,#FF,#06,#FF,#FF,#1D,#FF,#FF       ;........
       DB       #7D,#FF,#FF,#62,#FF,#FF,#41,#7F       ;}..b..A.
       DB       #FF,#81,#7F,#FF,#80,#BF,#FF,#02       ;.....?..
       DB       #FF,#F6,#0E,#FF,#F4,#0E,#FF,#E8       ;.v..t..h
       DB       #0F,#FF,#E8,#1F,#FF,#E8,#1F,#FF       ;..h..h..
       DB       #E8,#77,#FF,#E8,#47,#FF,#F7,#82       ;hw.hG.w.
       DB       #FF,#F8,#00,#FF,#FF,#FF,#FF,#FF       ;.x......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FE,#00,#FF,#FD,#FF,#FF,#FE       ;.~..}..~
       DB       #7F,#FF,#FF,#80,#FF,#FF,#FF,#81       ;........
       DB       #40,#BF,#FF,#40,#5F,#FF,#A0,#5F       ;@?.@_. _
       DB       #FF,#D0,#6F,#FF,#E8,#2F,#FF,#F6       ;.Po.h/.v
       DB       #73,#FF,#F9,#ED,#FF,#FE,#C2,#FF       ;s.ym.~B.
       DB       #FE,#C1,#7F,#FF,#41,#7F,#FF,#A3       ;~A..A..#
       DB       #BF,#FF,#BF,#BF,#FF,#BF,#BF,#FF       ;?.??.??.
       DB       #DF,#7F,#FF,#DF,#BF,#FF,#E7,#DF       ;_.._?.g_
       DB       #00,#01,#DF,#FC,#01,#EF,#FF,#C3       ;.._|.o.C
       DB       #F7,#FF,#FF,#F7,#00,#0F,#CF,#02       ;w..w..O.
       DB       #FF,#FF,#CE,#FF,#FF,#BF,#FF,#FF       ;..N..?..
       DB       #BF,#FF,#FF,#00,#FF,#FF,#60,#FF       ;?.....`.
       DB       #FF,#5B,#FF,#FF,#40,#FF,#FF,#64       ;.[..@..d
       DB       #FF,#FF,#60,#FF,#FE,#EE,#FF,#FC       ;..`.~n.|
       DB       #F1,#FF,#F3,#EF,#FF,#EF,#07,#FF       ;q.so.o..
       DB       #D8,#00,#FF,#A0,#21,#FF,#40,#12       ;X.. !.@.
       DB       #FE,#C0,#00,#FE,#A4,#00,#FE,#86       ;~@.~$.~.
       DB       #04,#FE,#8F,#00,#FD,#07,#F1,#01       ;.~..}.q.
       DB       #7F,#FF,#FF,#BF,#FF,#FF,#BF,#FF       ;...?..?.
       DB       #FF,#5F,#FF,#FF,#5F,#FF,#FF,#5F       ;._.._.._
       DB       #FF,#FF,#5F,#FF,#FF,#DF,#FF,#FF       ;.._.._..
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#EF,#FF       ;o..o..o.
       DB       #FF,#F3,#FF,#FF,#1C,#FF,#FF,#03       ;.s......
       DB       #7F,#FF,#01,#7F,#FF,#01,#BF,#FF       ;......?.
       DB       #00,#BF,#FF,#08,#BF,#FF,#08,#DF       ;.?..?.._
       DB       #FF,#08,#5F,#FF,#F8,#5F,#FF,#02       ;.._.x_..
       DB       #FD,#87,#84,#FD,#0A,#10,#FD,#12       ;}..}..}.
       DB       #00,#FA,#11,#10,#FA,#21,#86,#FA       ;.z..z!.z
       DB       #11,#00,#FA,#11,#E0,#FA,#11,#FF       ;..z.`z..
       DB       #FD,#23,#FF,#FD,#23,#FF,#FD,#23       ;}#.}#.}#
       DB       #FF,#FD,#17,#1F,#FD,#56,#1F,#FD       ;.}..}V.}
       DB       #0C,#0F,#FE,#8C,#0F,#FE,#88,#08       ;..~..~..
       DB       #FF,#78,#18,#FF,#88,#30,#FF,#D0       ;.x...0.P
       DB       #50,#FF,#D0,#A0,#FF,#D0,#20,#01       ;P.P .P .
       DB       #7C,#5F,#FF,#1C,#5F,#FF,#14,#5F       ;|_.._.._
       DB       #FF,#14,#5F,#FF,#66,#6F,#FF,#23       ;.._.fo.#
       DB       #2F,#FF,#F2,#2F,#FF,#F2,#2F,#FF       ;/.r/.r/.
       DB       #F9,#2F,#FF,#F9,#2F,#FF,#FD,#AF       ;y/.y/.}/
       DB       #FF,#8C,#97,#FF,#04,#8B,#FF,#06       ;........
       DB       #CB,#FF,#06,#C5,#FF,#03,#D5,#FF       ;K..E..U.
       DB       #03,#7D,#FF,#C1,#6D,#FF,#A1,#2B       ;.}.Am.!+
       DB       #FF,#C1,#2B,#FF,#41,#15,#FF,#80       ;.A+.A...
       DB       #FF,#D0,#DF,#FF,#D0,#DF,#FF,#D1       ;.P_.P_.Q
       DB       #BF,#FF,#BF,#7F,#FF,#6D,#7F,#FF       ;?.?..m..
       DB       #41,#7F,#FF,#43,#7F,#FE,#82,#FF       ;A..C.~..
       DB       #FD,#86,#FF,#FD,#ED,#FF,#FD,#FD       ;}..}m.}}
       DB       #FF,#FE,#FD,#FF,#FE,#FD,#FF,#FE       ;.~}.~}.~
       DB       #FB,#FF,#FE,#F7,#FF,#FD,#EF,#FF       ;{.~w.}o.
       DB       #FB,#E0,#00,#FB,#F0,#3F,#F7,#F3       ;{`.{p?ws
       DB       #FF,#EF,#FF,#E0,#EF,#FF,#1F,#81       ;.o.`o...
       DB       #61,#15,#FF,#A1,#15,#FF,#D1,#15       ;a..!..Q.
       DB       #FF,#DF,#8A,#FF,#D6,#8A,#FF,#D0       ;._..V..P
       DB       #CA,#FF,#D0,#4A,#FF,#E8,#45,#7F       ;J.PJ.hE.
       DB       #ED,#E5,#7F,#EF,#E5,#7F,#EF,#E5       ;me.oe.oe
       DB       #7F,#EF,#E3,#7F,#F7,#C3,#7F,#FB       ;.oc.wC.{
       DB       #C0,#FF,#FB,#DF,#FF,#FB,#DF,#FF       ;@.{_.{_.
       DB       #01,#EF,#FF,#FB,#F7,#FF,#FF,#FB       ;.o.{w..{
       DB       #FF,#FF,#FD,#FF,#0F,#FD,#FF,#01       ;..}..}..
       DB       #CF,#FF,#FF,#B3,#FF,#FF,#CC,#FF       ;O..3..L.
       DB       #FF,#73,#3F,#FF,#4C,#C1,#FF,#43       ;.s?.LA.C
       DB       #36,#FF,#40,#CB,#1F,#C0,#3B,#6F       ;6.@K.@;o
       DB       #E0,#0A,#17,#E0,#0E,#1B,#F0,#01       ;`..`..p.
       DB       #FD,#DF,#01,#3D,#00,#81,#23,#00       ;}_.=..#.
       DB       #42,#5F,#00,#24,#5F,#04,#18,#5F       ;B_.$_.._
       DB       #04,#18,#BF,#0E,#10,#BF,#0F,#01       ;..?..?..
       DB       #7F,#0C,#C2,#FF,#F8,#3D,#FF,#01       ;..B.x=..
       DB       #77,#FF,#FF,#17,#FF,#FF,#17,#FF       ;w.......
       DB       #FF,#17,#FF,#FF,#6F,#FF,#FF,#2F       ;....o../
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #FB,#FF,#FF,#FB,#FF,#FF,#FD,#FF       ;{..{..}.
       DB       #FF,#8D,#FF,#FF,#05,#FF,#FF,#06       ;........
       DB       #FF,#FF,#06,#FF,#FF,#02,#FF,#FF       ;........
       DB       #03,#7F,#FF,#C1,#7F,#FF,#A1,#7F       ;...A..!.
       DB       #FF,#C1,#7F,#FF,#41,#7F,#FF,#81       ;.A..A...
       DB       #61,#7F,#FF,#A1,#7F,#FF,#D1,#7F       ;a..!..Q.
       DB       #FF,#DF,#BF,#FF,#D6,#BF,#FF,#D0       ;._?.V?.P
       DB       #DF,#FF,#D0,#5F,#FF,#E8,#5F,#FF       ;_.P_.h_.
       DB       #ED,#EF,#FF,#EF,#EF,#FF,#EF,#EF       ;mo.oo.oo
       DB       #FF,#EF,#EF,#FF,#F7,#DF,#FF,#FB       ;.oo.w_.{
       DB       #DF,#FF,#FB,#DF,#FF,#FB,#DF,#FF       ;_.{_.{_.
       DB       #01,#EF,#FF,#FB,#F7,#FF,#FF,#FB       ;.o.{w..{
       DB       #FF,#FF,#FD,#FF,#0F,#FD,#FF,#01       ;..}..}..
       DB       #04,#5F,#FF,#86,#5F,#FF,#8A,#5F       ;._.._.._
       DB       #FF,#48,#5F,#FF,#48,#5F,#FF,#48       ;.H_.H_.H
       DB       #5F,#FF,#44,#5F,#FF,#D0,#5F,#FF       ;_.D_.P_.
       DB       #D0,#9F,#FF,#E0,#9F,#FF,#E0,#9F       ;P..`..`.
       DB       #FF,#C0,#BF,#FF,#09,#3F,#FF,#C5       ;.@?..?.E
       DB       #7F,#FF,#05,#7F,#FF,#0E,#FF,#FF       ;........
       DB       #0E,#FF,#FF,#1D,#FF,#FF,#3D,#FF       ;......=.
       DB       #FF,#FB,#FF,#FF,#F7,#FF,#FF,#01       ;.{..w...
       DB       #77,#FF,#FF,#17,#FF,#FF,#17,#FF       ;w.......
       DB       #FF,#17,#FF,#FF,#6F,#FF,#FF,#2F       ;....o../
       DB       #FF,#FF,#F7,#FF,#FF,#F7,#FF,#FF       ;..w..w..
       DB       #FB,#FF,#FF,#FB,#FF,#FF,#FD,#FF       ;{..{..}.
       DB       #FF,#8D,#FF,#FF,#05,#FF,#FF,#06       ;........
       DB       #FF,#FF,#06,#FF,#FF,#02,#FF,#FF       ;........
       DB       #03,#7F,#FF,#C1,#7F,#FF,#A1,#7F       ;...A..!.
       DB       #FF,#C1,#7F,#FF,#41,#7F,#FF,#02       ;.A..A...
       DB       #FF,#FD,#80,#FF,#FD,#83,#FF,#FD       ;.}..}..}
       DB       #47,#FF,#FE,#A0,#FF,#FE,#A7,#FF       ;G.~ .~'.
       DB       #FE,#AF,#FF,#FF,#5F,#FF,#FF,#5F       ;~/.._.._
       DB       #FF,#FF,#5F,#FF,#FF,#AF,#FF,#FF       ;.._../..
       DB       #AF,#FF,#FE,#6F,#FF,#FD,#B6,#FF       ;/.~o.}6.
       DB       #FA,#15,#FF,#F4,#14,#FF,#F4,#0A       ;z..t..t.
       DB       #FF,#EA,#0A,#FF,#D0,#4A,#FF,#D0       ;.j..PJ.P
       DB       #65,#FF,#A0,#75,#FF,#A1,#DF,#01       ;e. u.!_.
       DB       #E7,#FF,#FF,#FB,#FF,#FF,#FD,#FF       ;g..{..}.
       DB       #FF,#05,#FF,#FF,#EB,#FF,#FF,#9B       ;....k...
       DB       #FF,#FF,#8B,#FF,#FF,#05,#FF,#FF       ;........
       DB       #0B,#FF,#FF,#8B,#FF,#FF,#FB,#FF       ;......{.
       DB       #FF,#70,#FF,#FF,#1F,#3F,#FF,#01       ;.p...?..
       DB       #DF,#FF,#10,#2F,#FF,#00,#2F,#FF       ;_../../.
       DB       #00,#17,#FF,#41,#17,#FF,#41,#17       ;...A..A.
       DB       #FF,#01,#0B,#FF,#BF,#0B,#FF,#02       ;....?...
       DB       #FF,#A3,#E2,#FF,#A0,#3E,#FF,#A0       ;.#b. >. 
       DB       #02,#FF,#DC,#02,#FF,#E3,#FF,#FF       ;..\..c..
       DB       #FC,#31,#FF,#FF,#D1,#FF,#FF,#BD       ;|1..Q..=
       DB       #FF,#FF,#BF,#FF,#FF,#BF,#FF,#FF       ;..?..?..
       DB       #BF,#FF,#FF,#B1,#FF,#FF,#A0,#FF       ;?..1.. .
       DB       #FF,#40,#FF,#FF,#40,#FF,#FF,#41       ;.@..@..A
       DB       #FF,#FE,#82,#FF,#FE,#85,#FF,#FE       ;.~..~..~
       DB       #81,#FF,#FD,#03,#FF,#FD,#02,#01       ;..}..}..
       DB       #43,#0B,#FF,#47,#8B,#FF,#3E,#0B       ;C..G..>.
       DB       #FF,#F8,#17,#FF,#10,#6F,#FF,#17       ;.x...o..
       DB       #9F,#FF,#1E,#7F,#FF,#FD,#FF,#FF       ;.....}..
       DB       #FE,#FF,#FF,#FE,#FF,#FF,#FE,#FF       ;~..~..~.
       DB       #FF,#F9,#7F,#FF,#F0,#BF,#FF,#F0       ;.y..p?.p
       DB       #5F,#FF,#E8,#5F,#FF,#C4,#2F,#FF       ;_.h_.D/.
       DB       #A0,#17,#FF,#90,#17,#FF,#08,#0B       ; .......
       DB       #FF,#04,#05,#FF,#02,#05,#FF,#80       ;........
       DB       #FF,#FA,#05,#FF,#FA,#0D,#FF,#FA       ;.z..z..z
       DB       #0B,#FF,#F3,#17,#FF,#EF,#6F,#FF       ;..s..oo.
       DB       #D1,#DF,#FF,#A0,#BF,#FF,#A0,#BF       ;Q_. ?. ?
       DB       #FF,#A1,#7F,#FF,#63,#7F,#FE,#FC       ;.!..c.~|
       DB       #FF,#FD,#FD,#FF,#FD,#FD,#FF,#FD       ;.}}.}}.}
       DB       #FB,#FF,#FB,#C7,#FF,#FB,#BF,#FF       ;{.{G.{?.
       DB       #F7,#C0,#00,#F7,#C0,#FF,#EF,#DF       ;w@.w@.o_
       DB       #FF,#EF,#FF,#FF,#F3,#80,#00,#81       ;.o..s...
       DB       #FE,#C2,#FF,#FE,#C2,#FF,#FF,#5E       ;~B.~B..^
       DB       #FF,#FF,#62,#FF,#FE,#82,#FF,#FE       ;..b.~..~
       DB       #82,#FF,#FE,#82,#FF,#FF,#42,#FF       ;..~...B.
       DB       #FF,#66,#FF,#FF,#7F,#7F,#FF,#7F       ;.f......
       DB       #7F,#FF,#BF,#7F,#FF,#BE,#FF,#FF       ;..?..>..
       DB       #DE,#FF,#FF,#EE,#FF,#FF,#EF,#3F       ;^..n..o?
       DB       #00,#1F,#DF,#FF,#9F,#E7,#FF,#FF       ;.._..g..
       DB       #FB,#E0,#00,#07,#1F,#FF,#FF,#B7       ;{`.....7
       DB       #F9,#F9,#FF,#F7,#A6,#FF,#F7,#01       ;yy.w&.w.
       DB       #07,#F7,#03,#39,#EF,#C5,#46,#EF       ;.w.9oEFo
       DB       #EC,#82,#EF,#FC,#41,#EF,#E3,#00       ;l.o|Aoc.
       DB       #EF,#C1,#08,#ED,#80,#01,#F5,#1C       ;oA.m..u.
       DB       #06,#F6,#0F,#0C,#F6,#0F,#F0,#F4       ;.v..v.pt
       DB       #18,#00,#EC,#3F,#00,#D0,#E3,#F0       ;..l?.Pcp
       DB       #D0,#7F,#FF,#D0,#0F,#FF,#EE,#00       ;P..P..n.
       DB       #30,#C7,#FC,#3F,#DF,#FF,#FF,#B8       ;0G|?_..8
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#07,#00       ;........
       DB       #00,#F9,#80,#07,#06,#80,#3B,#F5       ;.y....;u
       DB       #80,#6C,#28,#83,#D0,#14,#7E,#60       ;.l(.P.~`
       DB       #03,#1F,#80,#E3,#3E,#01,#81,#3C       ;...c>..<
       DB       #02,#C0,#F8,#04,#31,#F8,#04,#0F       ;.@x.1x..
       DB       #F8,#0F,#F7,#FF,#FF,#FF,#00,#00       ;x.w.....
       DB       #1F,#FF,#FF,#FF,#FF,#FF,#E0,#01       ;......`.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#0F,#FF,#FF       ;........
       DB       #F7,#FF,#FF,#F7,#FF,#FF,#F7,#FF       ;w..w..w.
       DB       #FF,#EB,#FF,#FF,#FB,#FF,#FF,#FC       ;.k..{..|
       DB       #1F,#FF,#EE,#EF,#FF,#FB,#EF,#FF       ;..no.{o.
       DB       #FF,#DF,#FF,#FF,#BF,#FF,#FF,#9F       ;._..?...
       DB       #FF,#FF,#EF,#FF,#1F,#9F,#FF,#02       ;..o.....
       DB       #FF,#FF,#FF,#FF,#FF,#E0,#FF,#FF       ;.....`..
       DB       #9E,#FF,#FF,#7F,#FF,#FF,#7C,#FF       ;......|.
       DB       #FE,#F3,#FF,#FF,#4E,#FF,#FE,#BD       ;~s..N.~=
       DB       #FF,#FE,#FC,#FF,#FE,#FC,#FF,#FF       ;.~|.~|..
       DB       #7E,#FF,#FF,#7D,#FF,#FF,#7C,#FF       ;~..}..|.
       DB       #FF,#7C,#FF,#FF,#5E,#FF,#FF,#B0       ;.|..^..0
       DB       #FF,#FF,#60,#FF,#FF,#40,#FF,#FE       ;..`..@.~
       DB       #80,#FF,#FE,#80,#FF,#FE,#82,#01       ;..~..~..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#7F,#FF       ;........
       DB       #FF,#BF,#FF,#FF,#DF,#FF,#FF,#DF       ;.?.._.._
       DB       #FF,#FF,#DF,#FF,#FF,#2F,#FF,#FF       ;.._../..
       DB       #20,#FF,#FF,#3F,#7F,#FF,#30,#BF       ; ..?..0?
       DB       #FF,#D0,#5F,#FF,#81,#5F,#FF,#80       ;.P_.._..
       DB       #2F,#FF,#10,#AF,#FF,#08,#AF,#FF       ;/../../.
       DB       #04,#AF,#FF,#04,#A0,#1F,#05,#B9       ;./.. ..9
       DB       #DF,#00,#EF,#2F,#08,#62,#2F,#02       ;_.o/.b/.
       DB       #FF,#FD,#07,#FF,#FD,#07,#FF,#FD       ;.}..}..}
       DB       #05,#FF,#FD,#1E,#FF,#FA,#10,#FF       ;..}..z..
       DB       #FA,#70,#FF,#FA,#30,#FF,#FA,#30       ;zp.z0.z0
       DB       #FF,#FA,#2C,#FF,#FA,#22,#FF,#FA       ;.z,.z".z
       DB       #21,#FF,#FA,#60,#FF,#FA,#40,#FF       ;!.z`.z@.
       DB       #FA,#40,#FF,#FA,#40,#FF,#F4,#40       ;z@.z@.t@
       DB       #FF,#8C,#60,#FF,#7C,#7F,#FE,#DF       ;..`.|.~_
       DB       #C0,#FF,#7F,#FF,#FF,#80,#00,#00       ;@.......
       DB       #00,#3F,#30,#00,#7B,#FC,#FF,#FC       ;.?0.{|.|
       DB       #02,#03,#F8,#03,#01,#F0,#1B,#70       ;..x..p.p
       DB       #F0,#0C,#B8,#F0,#3E,#1C,#F9,#CC       ;p.8p>.yL
       DB       #0F,#FE,#04,#1B,#F0,#06,#FF,#80       ;.~..p...
       DB       #03,#FF,#00,#01,#FF,#80,#01,#FF       ;........
       DB       #C0,#01,#07,#E0,#00,#03,#E0,#00       ;@..`..`.
       DB       #03,#C3,#E0,#FF,#FF,#FF,#00,#00       ;.C`.....
       DB       #1F,#FF,#FF,#FF,#00,#00,#00,#01       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#7F,#FF,#FF,#BF,#FF,#FF,#5F       ;....?.._
       DB       #FF,#FF,#6F,#FF,#FF,#17,#FF,#FF       ;..o.....
       DB       #0B,#FF,#FF,#1D,#FF,#FF,#FE,#FF       ;......~.
       DB       #FF,#FE,#FF,#FF,#FC,#FF,#FF,#FF       ;.~..|...
       DB       #7F,#FF,#3F,#7F,#FF,#0F,#83,#FF       ;..?.....
       DB       #07,#FD,#FF,#C7,#FE,#FF,#FF,#FD       ;.}.G~..}
       DB       #FF,#FF,#F3,#FF,#00,#0F,#FF,#B9       ;..s....9
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#00,#0F       ;........
       DB       #FC,#FF,#F3,#FB,#80,#4C,#F2,#0B       ;|.s{.Lr.
       DB       #F3,#EC,#07,#F9,#E8,#07,#FD,#02       ;sl.yh.}.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FE       ;.......~
       DB       #FF,#FF,#FF,#FF,#FF,#FD,#FF,#FF       ;.....}..
       DB       #FD,#FF,#FF,#FA,#FF,#C4,#7A,#FF       ;}..z.Dz.
       DB       #BB,#84,#FF,#7F,#E8,#FE,#FF,#98       ;;...h~..
       DB       #FD,#FE,#00,#FB,#FE,#10,#F7,#FE       ;}~.{~.w~
       DB       #10,#F7,#CF,#F1,#F7,#FF,#FF,#BA       ;.wOqw..:
       DB       #10,#0F,#FD,#20,#0F,#FD,#40,#EF       ;..} .}@o
       DB       #FD,#41,#CF,#FD,#8B,#C7,#FE,#87       ;}AO}.G~.
       DB       #67,#FA,#83,#17,#EA,#C3,#07,#65       ;gz..jC.e
       DB       #61,#1D,#2D,#11,#E0,#33,#08,#E7       ;a.-.`3.g
       DB       #CF,#04,#3D,#DF,#06,#1C,#6F,#0E       ;O.=_..o.
       DB       #5E,#17,#3E,#4E,#0B,#53,#F3,#05       ;^.>N.Ss.
       DB       #23,#FC,#C2,#47,#FF,#32,#87,#BC       ;#|BG.2.<
       DB       #CA,#FF,#FF,#F3,#FF,#FF,#FF,#02       ;J..s....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#F0,#FF,#F8,#0F,#FF,#87,#F0       ;.p.x...p
       DB       #F0,#78,#00,#8F,#F0,#00,#6F,#F0       ;px..p.op
       DB       #02,#6F,#E0,#0E,#6F,#F8,#3E,#01       ;.o`.ox>.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#1F       ;........
       DB       #FF,#FF,#EF,#FF,#FF,#2F,#FF,#FF       ;..o../..
       DB       #17,#FF,#FF,#17,#FF,#FF,#17,#FF       ;........
       DB       #FF,#2F,#FF,#FF,#2F,#FF,#FF,#BB       ;./../..;
       DB       #6F,#81,#E2,#6F,#C1,#34,#68,#11       ;o.boA4h.
       DB       #38,#6A,#11,#E8,#2A,#BE,#08,#07       ;8j.h*>..
       DB       #C1,#E9,#38,#3E,#2F,#C7,#C1,#3D       ;Ai8>/GA=
       DB       #3A,#01,#CC,#02,#1F,#0C,#FA,#08       ;:.L...z.
       DB       #08,#FD,#08,#08,#FD,#08,#08,#FD       ;.}..}..}
       DB       #08,#08,#FA,#08,#08,#04,#18,#08       ;..z.....
       DB       #78,#60,#04,#81,#C0,#04,#86,#1F       ;x`..@...
       DB       #FE,#FF,#FF,#FF,#FF,#FF,#FB,#01       ;~.....{.
       DB       #37,#FF,#FF,#7B,#FF,#FF,#FB,#FF       ;7..{..{.
       DB       #FF,#FD,#FF,#FF,#E2,#FF,#FF,#C1       ;.}..b..A
       DB       #7F,#FF,#C0,#BF,#FF,#C0,#BF,#FF       ;..@?.@?.
       DB       #F0,#40,#7F,#E0,#27,#9F,#38,#17       ;p@.`'.8.
       DB       #EF,#38,#1D,#E7,#3E,#08,#FB,#3F       ;o8.g>.{?
       DB       #08,#F9,#3F,#84,#FE,#2E,#40,#FE       ;.y?.~.@~
       DB       #2E,#31,#DE,#2F,#FF,#8E,#3F,#FF       ;.1^/..?.
       DB       #FD,#3F,#E0,#03,#F8,#1F,#FF,#02       ;}?`.x...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FC,#FF,#FF       ;.....|..
       DB       #C3,#FF,#FF,#3D,#FF,#FC,#D0,#FF       ;C..=.|P.
       DB       #F3,#9C,#FF,#EF,#DB,#FF,#DF,#E6       ;s..o[._f
       DB       #FF,#DF,#E9,#FF,#DF,#ED,#FF,#DF       ;._i._m._
       DB       #FD,#FF,#DF,#FF,#FF,#DF,#CF,#BC       ;}._.._O<
       DB       #FF,#FF,#FF,#FF,#FF,#07,#FF,#FE       ;.......~
       DB       #F8,#FF,#FD,#07,#FF,#FA,#1F,#FF       ;x.}..z..
       DB       #F4,#38,#FF,#E8,#F0,#FF,#D3,#C0       ;t8.hp.S@
       DB       #FF,#A7,#81,#00,#46,#01,#E0,#CC       ;.'..F.`L
       DB       #03,#9F,#F8,#04,#00,#F8,#08,#48       ;..x..x.H
       DB       #3C,#10,#9E,#3E,#70,#01,#FF,#E0       ;<..>p..`
       DB       #00,#00,#FE,#00,#00,#03,#80,#07       ;..~.....
       DB       #C0,#FF,#FF,#FF,#FF,#FF,#FF,#01       ;@.......
       DB       #7F,#FF,#FF,#BF,#FF,#FF,#DF,#FF       ;...?.._.
       DB       #FF,#AF,#FF,#FF,#D7,#FF,#FF,#6B       ;./..W..k
       DB       #FF,#FF,#34,#FF,#FF,#1B,#7F,#FF       ;..4.....
       DB       #07,#BF,#FF,#03,#DF,#FF,#07,#DF       ;.?.._.._
       DB       #FF,#FF,#E3,#FF,#3F,#BC,#3F,#3F       ;..c.?<??
       DB       #FF,#DF,#3B,#FF,#EF,#03,#FF,#EF       ;._;.o..o
       DB       #01,#FF,#9F,#F1,#FF,#DF,#FF,#FF       ;...q._..
       DB       #DF,#FF,#FC,#3F,#00,#03,#FF,#02       ;_.|?....
       DB       #FF,#FF,#CE,#FF,#FF,#BF,#FF,#FF       ;..N..?..
       DB       #BF,#FF,#FF,#80,#FF,#FF,#60,#FF       ;?.....`.
       DB       #FF,#5B,#FF,#FF,#40,#FF,#FE,#E4       ;.[..@.~d
       DB       #FF,#FE,#E0,#FF,#FE,#EE,#FF,#FC       ;.~`.~n.|
       DB       #EE,#F0,#03,#F1,#E8,#0F,#0F,#D4       ;np.qh..T
       DB       #18,#0E,#D4,#20,#21,#D4,#40,#12       ;..T !T@.
       DB       #D4,#C0,#00,#D4,#A4,#00,#D4,#86       ;T@.T$.T.
       DB       #04,#D4,#8F,#00,#D5,#07,#F0,#01       ;.T..U.p.
       DB       #7F,#FF,#FF,#BF,#FF,#FF,#BF,#FF       ;...?..?.
       DB       #FF,#3F,#FF,#FF,#DF,#FF,#FF,#5F       ;.?.._.._
       DB       #FF,#FF,#5F,#FF,#FF,#EF,#FF,#FF       ;.._..o..
       DB       #EF,#FF,#FF,#EF,#FF,#FF,#EF,#FF       ;o..o..o.
       DB       #FF,#EF,#FF,#FF,#F3,#FF,#FF,#0D       ;.o..s...
       DB       #FF,#FF,#02,#FF,#FF,#02,#FF,#FF       ;........
       DB       #01,#7F,#FF,#11,#7F,#FF,#11,#BF       ;.......?
       DB       #FF,#30,#BF,#FF,#F0,#BF,#FF,#02       ;.0?.p?..
       DB       #D5,#87,#86,#D6,#8A,#00,#D6,#3A       ;U..V..V:
       DB       #00,#96,#32,#00,#77,#E1,#80,#55       ;..2.wa.U
       DB       #41,#C0,#A3,#81,#F8,#BF,#81,#FF       ;A@#.x?..
       DB       #A7,#03,#FF,#A3,#03,#FF,#BF,#03       ;'..#..?.
       DB       #FF,#DC,#07,#1F,#C8,#06,#1F,#C8       ;.\..H..H
       DB       #04,#0F,#F0,#04,#0F,#FF,#E8,#0A       ;..p...h.
       DB       #FF,#E8,#1B,#FF,#E8,#31,#FF,#D0       ;.h..h1.P
       DB       #50,#FF,#D0,#A0,#FF,#D0,#20,#01       ;P.P .P .
       DB       #30,#BF,#FF,#30,#BF,#FF,#39,#BF       ;0?.0?.9?
       DB       #FF,#28,#5F,#FF,#A8,#2F,#FF,#E4       ;.(_.(/.d
       DB       #20,#7F,#E2,#1F,#BF,#E1,#A0,#5F       ; .b.?a _
       DB       #E0,#61,#BF,#F0,#1E,#7F,#B8,#01       ;`a?p..8.
       DB       #FF,#8B,#FF,#FF,#8D,#FF,#FF,#45       ;.......E
       DB       #FF,#FF,#42,#FF,#FF,#23,#7F,#FF       ;..B..#..
       DB       #01,#7F,#FF,#01,#BF,#FF,#80,#BF       ;....?..?
       DB       #FF,#40,#5F,#FF,#20,#5F,#FF,#02       ;.@_. _..
       DB       #FF,#FF,#CE,#FF,#FF,#BF,#FF,#FF       ;..N..?..
       DB       #BF,#FF,#FF,#80,#FF,#FF,#60,#FF       ;?.....`.
       DB       #FF,#5B,#FF,#FF,#40,#FF,#FE,#E4       ;.[..@.~d
       DB       #FF,#FE,#E0,#FF,#FE,#EE,#FF,#FC       ;.~`.~n.|
       DB       #F1,#F0,#03,#EF,#E8,#0F,#06,#D4       ;qp.oh..T
       DB       #18,#00,#D4,#20,#21,#D4,#40,#12       ;..T !T@.
       DB       #D4,#C0,#00,#D4,#A4,#00,#D4,#86       ;T@.T$.T.
       DB       #04,#D4,#8F,#00,#D5,#07,#F0,#02       ;.T..U.p.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FC,#FF       ;......|.
       DB       #FF,#F3,#FF,#FF,#EF,#FF,#FF,#DF       ;.s..o.._
       DB       #FF,#FF,#C0,#FF,#FF,#BF,#FF,#FF       ;..@..?..
       DB       #7E,#FF,#FF,#7E,#FF,#FF,#7C,#01       ;~..~..|.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#7F,#FF,#FF,#9F       ;........
       DB       #FF,#FF,#EF,#FF,#FF,#F7,#FF,#FF       ;..o..w..
       DB       #37,#FF,#FF,#A0,#3F,#FF,#61,#DF       ;7.. ?.a_
       DB       #FF,#22,#5F,#FF,#14,#BF,#FF,#02       ;."_..?..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FC,#FF,#FF,#F3,#FF       ;...|..s.
       DB       #FF,#EF,#FF,#FF,#DF,#FF,#FF,#C0       ;.o.._..@
       DB       #FF,#FF,#BF,#FF,#FF,#BE,#FF,#FF       ;..?..>..
       DB       #7C,#FF,#FE,#FC,#FF,#FD,#FC,#FF       ;|.~|.}|.
       DB       #FD,#FC,#FF,#E1,#FF,#FE,#1F,#FC       ;}|.a.~.|
       DB       #F1,#F0,#0F,#CE,#00,#02,#B0,#00       ;qp.N..0.
       DB       #04,#A0,#00,#09,#A1,#61,#72,#01       ;. ..!ar.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#7F,#FF,#FF,#80,#07,#FF,#E0       ;.......`
       DB       #3B,#FF,#F0,#4B,#FF,#30,#97,#FF       ;;.pK.0..
       DB       #A1,#2F,#FF,#62,#5F,#FF,#24,#BF       ;!/.b_.$?
       DB       #FF,#19,#7F,#FF,#32,#FF,#FF,#65       ;....2..e
       DB       #FF,#FF,#4B,#FF,#FF,#97,#FF,#FF       ;..K.....
       DB       #23,#FF,#FF,#7C,#00,#03,#83,#EF       ;#..|...o
       DB       #1D,#00,#10,#E2,#00,#00,#0D,#02       ;...b....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#F0,#FF,#FE       ;.....p.~
       DB       #0F,#FF,#F9,#F8,#FF,#F6,#18,#03       ;..yx.v..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#07,#FF,#00,#F9,#00,#FF       ;.....y..
       DB       #06,#7F,#00,#F9,#40,#FF,#07,#02       ;...y@...
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FC,#FF,#FF       ;.....|..
       DB       #F3,#FF,#FF,#CC,#FF,#FF,#B1,#01       ;s..L..1.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #07,#FF,#FF,#7B,#FF,#FF,#84,#FF       ;...{....
       DB       #FF,#B3,#7F,#FF,#C0,#BF,#FF,#03       ;.3..@?..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#E0,#FF,#FF       ;.....`..
       DB       #9F,#00,#FF,#60,#FF,#00,#9F,#00       ;...`....
       DB       #FE,#E0,#FF,#02,#FF,#00,#FE,#01       ;~`....~.
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#0F,#FF,#FF,#F0,#7F       ;......p.
       DB       #FF,#1F,#9F,#FF,#18,#6F,#FF,#03       ;.....o..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FB,#FF,#FF,#F5       ;....{..u
       DB       #FF,#FF,#F6,#FF,#FF,#F5,#7F,#FF       ;..v..u..
       DB       #F5,#7F,#FF,#FA,#BF,#FF,#FA,#BF       ;u..z?.z?
       DB       #FF,#FD,#5F,#FF,#FD,#5F,#FF,#FE       ;.}_.}_.~
       DB       #AF,#FF,#FE,#AF,#FF,#FF,#57,#FF       ;/.~/..W.
       DB       #FF,#57,#FF,#FF,#AB,#FF,#FF,#AB       ;.W..+..+
       DB       #FF,#FF,#D5,#FF,#FF,#D5,#FF,#02       ;..U..U..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#F0,#00,#00,#EF,#FF,#FF,#D0       ;.p..o..P
       DB       #00,#00,#EF,#FF,#FF,#F0,#00,#00       ;..o..p..
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF       ;.....
L_FEFE       DB       #FF,#FF,#BF,#FF,#FF,#FF,#FF,#FF       ;..?.....
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#F3,#FF,#FF,#ED,#FF       ;...s..m.
       DB       #FF,#EA,#1F,#FF,#0B,#E3,#FF,#FA       ;.j...c.z
       DB       #3D,#FF,#0A,#3D,#FF,#FA,#E3,#FF       ;=..=.zc.
       DB       #0B       ;.
L_FF2F       DB       #2F,#FF,#ED,#2F,#FF,#ED,#2F,#FF       ;/.m/.m/.
       DB       #F1,#2F,#FF,#FA,#2F,#FF,#FA,#2F       ;q/.z/.z/
       DB       #FF,#00,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#21,#FF,#FF,#FF,#FF,#FF,#FF       ;.!......
       DB       #FF,#FF,#FF,#FF,#FF,#FF,#FF,#FF       ;........
       DB       #FF,#FF,#FF
      if 1==0
       db #DB,#02,#4D,#00,#C1       ;...[.M.A
       DB       #51,#1F,#00,#E1,#51,#0C,#03,#E0       ;Q..aQ..`
       DB       #57,#71,#0E,#CE,#0B,#D3,#50,#CE       ;Wq.N.SPN
       DB       #0B,#D4,#50,#0D,#16,#F3,#0D,#CE       ;.TP..s.N
       DB       #0B,#E0,#50,#21,#15,#DC,#0A,#D7       ;.`P!.\.W
       DB       #18,#B1,#33,#A7,#64,#05,#00,#B1       ;.13'd..1
       DB       #33,#A7,#64,#00,#00,#A2,#64,#9E       ;3'd.."d.
       DB       #64,#DB,#02,#4D,#00,#00,#0A,#C6       ;d[.M...F
       DB       #2B,#44,#00,#00,#5C,#00,#0A,#C6       ;+D..\..F
       DB       #2B,#00,#0A,#CA,#2B,#00,#FF,#05       ;+..J+...
       DB       #01,#17,#29,#FF,#00,#0F,#3C,#BE       ;..)...<>
       DB       #3C,#2B,#2D,#65,#33,#58,#27,#ED       ;<+-e3X'm
       DB       #10,#0D,#00,#09,#00,#85,#1C,#10       ;........
       DB       #1C,#52,#1B,#76,#1B,#A8,#89,#FF       ;.R.v.(..
       DB       #3E       ;>
      endif
;#0000
;
