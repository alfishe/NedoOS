        ;MAIN "*",#C6
BEGIN
        CALL CLSCRS ;будет установлен curscr=0

        LD HL,muzRETER
        LD (muzer),HL ;выключили музыку

      ;глушим оба AY
        LD A,pgmuz
        CALL OUTA
        CALL muz ;shut
      
        LD de,muzmenuNAME
        OS_OPENHANDLE
	push bc
	ld de,muzmenu
	ld hl,0x4000
	OS_READHANDLE
	pop bc
	OS_CLOSEHANDLE

        CALL muz ;start muz

        LD HL,muz+5
        LD (muzer),HL ;играем музыку заставки

;-------- DEPK LOGO
        ld de,titlefilename
        call loadpic       
        call showscrdata
        CALL SCR1toSCR2

        CALL MKMASK ;строим таблицу масок и Y

        LD C,0
        LD HL,THIGH
_y=160
_x=7
        xy2adr
        LD DE,_a ;#D0CB
        CALL PRTXT88

       ;LD HL,TLAST
_y=160
_x=20
        xy2adr
        LD DE,_a ;#D0CB
        CALL PRTXT88

        LD HL,(hiscore)
_y=160+8
_x=7
        xy2adr
        LD DE,_a ;#D0B8
        CALL PR12345

        LD HL,(lascore)
_y=160+8
_x=20
        xy2adr
        LD DE,_a ;#D0B8
        CALL PR12345

       HALT 
       LD HL,TRUNLINE+TRUNLINE2
curRL=$+1
       LD DE,TRUNLINE2
       OR A
       SBC HL,DE
       LD (curRL),HL
       LD (RUNLADR),HL
        XOR A
        LD (RLphase),A
LOGOnK0
        ;LD A,p14
        CALL OUTscr_low_cur
        call setpgscr_high_cur4000
_y=176+8
_x=0
        xy2adr
        LD DE,_a ;#C000+
        LD B,8
RUNLRL1
       PUSH BC
       PUSH DE
;#C001+ -> buf
        LD H,D,L,E
        LD DE,#A000;REBUF1
        CALL RLLDIR32
;#4000+ -> #C000+
        RES 7,H
        CALL RLLDIR32
;#E000+ -> #4000+
        SET 5,H
        SET 7,H
        CALL RLLDIR32
;#6000+ -> #E000+
        RES 7,H
        CALL RLLDIR32
;buf -> #6000+
        LD HL,#A001;REBUF1+1
        LD C,31
        LDIR 
       POP DE
       POP BC
        CALL DDE
        DJNZ RUNLRL1

        LD A,pgpic ;там текст
        CALL OUTA
RUNLADR=$+1
        LD HL,0
RLphase=$+1
        LD A,0
        OR A
        jr NZ,RLnosym
        INC HL
        LD (RUNLADR),HL
        BIT 7,(HL)
        jr Z,RLnosym
       LD A,55
       LD (showdemo),A
       LD HL,DEMO1+DEMO2
curdemo=$+1
       LD DE,DEMO1
       OR A
       SBC HL,DE
       LD (curdemo),HL
       LD (demoRADR),HL
        LD A,1^3 ;const
        XOR 3 ;var (1/3=l2dem/l4dem)
        LD ($-1),A
        LD (world),A
       JR LOGOSLW ;строка кончилась - покажем дему
RLnosym
        LD A,(HL)
        LD C,0 ;фоновый цвет
        CALL PR88PREP
        LD A,(RLphase)
       LD E,A
        ADD A,L
        LD L,A
       LD A,E
        ADD A,8
        AND #18
        LD (RLphase),A

_y=176+8
_x=31
        xy2adr
       IF msx
        LD DE,_a+3
       ELSE 
        LD DE,_a-#6000 ;будет #6000+
       ENDIF 
        CALL CHRSTOLB
        call setpgmain4000

        XOR A
        LD (world),A
       LD A,55+128
       LD (showdemo),A
        HALT 
        LD A,#FD
        IN A,(-2) ;A..G
        BIT 1,A ;'S'
        jr NZ,LOGOnKS
LOGOSLW LD A,31 ;SLOW
        JR LOGOQQ
LOGOnKS
        BIT 3,A ;'F'
        JP NZ,LOGOnK0
        LD A,183 ;FAST
LOGOQQ
        LD (SLOWON),A
;------------------------------
    ;новая игра
        LD HL,0
        call INVALIDATESCORE_hl

        LD HL,lives
        LD (HL),beglives

NEWLEVEL

       ;LD A,8
       ;LD (curscr),A ;для распаковки
       HALT 

        LD A,(world)
       AND 7
        ADD A,"1"
        LD (levNAME+3),A
        LD (picNAME+4),A
        LD (muzNAME+3),A

        LD HL,muzRETER
        LD (muzer),HL ;выключили музыку

      ;глушим оба AY
        LD A,pgmuz
        CALL OUTA
        CALL muz ;shut

        ld a,(world)
        call findpicfilename_a
        ex de,hl
        call loadpic

        LD de,levNAME
        OS_OPENHANDLE
	push bc
	ld de,HEROESFROM
	ld hl,HEROESFROMsz
	OS_READHANDLE
	pop bc
	OS_CLOSEHANDLE

        LD A,pgmuz
        CALL OUTA
        CALL muz ;shut

        LD de,muzNAME
        OS_OPENHANDLE
	push bc
	ld de,muzmenu
	ld hl,0x4000
	OS_READHANDLE
	pop bc
	OS_CLOSEHANDLE

        CALL muz ;start muz

        LD HL,muz+5
        LD (muzer),HL ;играем музыку заставки
        ;EI   ;muz делает DI

       LD HL,(score)
       LD (tlevelscore),HL
NEWLIFE
      IF demorec
      LD HL,DEMO1
      LD (demoRADR),HL
      ENDIF 
tlevelscore=$+1
       LD HL,0
       call INVALIDATESCORE_hl
        CALL OUTIQ
        LD A,50
        LD (clktimer),A
       XOR A
       LD (cycler),A
        LD H,A,L,A
        LD (weighttime),HL
        LD (bottletime),HL
        LD (falladd),HL
       DEC A
       LD (bouncedX),A
       LD (bouncedY),A
        LD A,55
        LD (UPAL),A ;не падал
        LD (SJEDEN),A ;не съеден
     ; LD HL,muz+5
     ; LD (muzer),HL ;играем музыку уровня,а не заморозки
        LD A,(world)
      INC A
        LD DE,TWORLD2
       LD C,10
       CALL DIGtoDE
       LD C,1
       CALL DIGtoDE

        call showscrdata
        CALL SCR1toSCR2 ;scrcur to scr

        LD C,0
        LD HL,TWORLD2
_y=168+8
_x=12
        xy2adr
       IF msx
        _a=136*3-160*128+_a
       ENDIF 
        LD DE,_a ;#D0A3
        CALL PRTXT88
        CALL PRLIVES
       LD HL,0
       CALL INCSCORE

        CALL MKMASK ;строим таблицу масок и Y

adrHEROES=$+1
        LD HL,HEROESFROM
       LD DE,TTIME2
       LD A,(HL)
       LD C,100
       CALL DIGtoDE
       LD C,10
       CALL DIGtoDE
       LD C,1
       CALL DIGtoDE
       INC HL,HL
        LD DE,HEROES
        LD BC,LHEROES
        LDIR 
       CALL PRCLK
       
       call depklevel      

        XOR A
        LD (gameover),A
       IF re
        LD (REBUF1-1),A ;хвост табл.восстанавливаемых кусков экр
        LD (REBUF2-1),A
        LD HL,REBUF1
        LD (READR1),HL
        ;LD HL,REBUF2
        ;LD (READR2),HL
       ENDIF 
        DEC A
        LD (SPRS),A ;ни одного спрайта в цепочке

        LD HL,gamescf
        LD (HL),55 ;включаем игру
;Работаем так:
;HALT
;вкл 2(1)-й экран
;восст.под спр. 1(2)-й экран
 ;[SCROLL 1(2)-й экран]
;вывод спр. на 1(2)-й экран
;взятие текущих координат спрайтов

        halt
        ld hl,(mkeytail)
        ld (mkeyhead),hl
        ld a,(timer)
        ld (oldtimer),a
        xor a
        ld (slowtimer),a

LOO
        call PersToSprs

       ;ld a,(curscr)
       ;or a
       ; JR Z,LOOSCR1
       IF re
READR1=$+1
        LD HL,0
        CALL ReSprs
       ENDIF 
gameover=$+1
       LD A,0
       OR A
       jr NZ,LOOQ
       IF re
        LD HL,REBUF1
        EXX 
       ENDIF 
        LD HL,SPRS
        CALL PrSprs
        call PRHUD
       IF re
        EXX 
        LD (READR1),HL
       ENDIF 

;закончили рисовать
       ld a,(timer)
       push af
        ;call changescrpg ;с этого момента (точнее, с прерывания) можем видеть, что нарисовали
       CALL curscrXOR8

;логика
;... её вызывать столько раз, сколько прошло прерываний!
LOOmainloop_uvwaittimer0
        ld hl,mkeyhead
        ld a,(mkeytail)
        cp (hl)
        jr z,LOOmainloop_uvwaittimer0

        ld a,(timer)
oldtimer=$+1
        ld b,0
        ld (oldtimer),a
        sub b
        ld b,a
        ;jr z,LOOmainloop_uvwaittimer0 ;если ни одного прерывания не прошло, крутимся тут

;b=сколько прошло прерываний
        ;cp 5
        ;jr c,$+4
        ;ld b,5
LOOmainloop_uvlogic0
        ;push bc
        call demokey_logic
        ;pop bc
        ;djnz LOOmainloop_uvlogic0
        ld hl,mkeyhead
        ld a,(mkeytail)
        cp (hl)
        jr nz,LOOmainloop_uvlogic0

;ждём физического переключения экрана!
;можем начать новую отрисовку, только если с момента changescrpg прошло хотя бы одно прерывание (возможно, внутри logic)
       pop bc ;b=timer на момент changescrpg
LOOwaitchangescr0
        ld a,(timer)
        cp b
        jr z,LOOwaitchangescr0

        JP LOO

;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;


LOOQ
        LD HL,gamescf
        LD (HL),183 ;выключаем игру
      LD HL,showdemo
      BIT 7,(HL)
      JP Z,BEGIN ;было SCF=55. выход из демы
        LD DE,(score)
        LD HL,(thigh)
        OR A
        SBC HL,DE
        jr NC,$+6
        LD (thigh),DE
;1=killed
;2=won
;3=time out
;4=break
      CP 4
      JP Z,BEGIN
        CP 2
        jr Z,LOOWON
       DEC A
       jr Z,LOOKIL
_y=48 +8
_x=8
        xy2adr
        LD BC,_a
_y=48+8 +8
_x=8
        xy2adr
        LD DE,_a
        LD HL,tTIMEOUT
        LD A,16 ;total symbols
        CALL MEGAPRMASK
       CALL ANYKEY ;18.3.07
LOOKIL
        LD HL,lives
LOODLIV DEC (HL)
        jr NZ,ANYKNEWLIFE
_y=48 +8+16
_x=7
        xy2adr
        LD BC,_a
_y=48+8 +8+16
_x=7
        xy2adr
        LD DE,_a
        LD HL,tGAMEOVER
        LD A,19 ;total symbols
        CALL MEGAPRMASK
        LD HL,(score)
        LD (lascore),HL
        LD DE,(hiscore)
        OR A
        SBC HL,DE
        ADD HL,DE
        jr C,$+5
        LD (hiscore),HL
        CALL ANYKEY
       CALL curscrXOR8
        JP BEGIN
ANYKNEWLIFE
       ;CALL ANYKEY ;Shiru suggested to remove
       CALL curscrXOR8
        JP NEWLIFE
LOOWON
_y=48 +8
_x=2
        xy2adr
        LD BC,_a
_y=48+8 +8
_x=2
        xy2adr
        LD DE,_a
        LD HL,tLEVCOM
        LD A,29 ;total symbols
        CALL MEGAPRMASK
WONTIME
        HALT 
        CALL TIMEBACK
        LD A,(gameover)
       CP 3
        jr Z,WONTIMEQ
        LD HL,5
        CALL INCSCORE
        LD A,fxscore2
        CALL AFXPRAY
        JR WONTIME
WONTIMEQ
      LD A,(clktimer)
      LD HL,-1
      INC HL
      SUB 10
      jr NC,$-3
      CALL INCSCORE
       IF msx
       CALL SHOWSCORE
       ENDIF 
       CALL ANYKEY
        LD HL,world
        INC (HL)
        LD A,(HL)
        SUB WORLDS
        jr NZ,$+3
        LD (HL),A
       JP NEWLEVEL
       ;LD A,(HL)
       ;CP worlds
       ;JP NZ,NEWLEVEL
       ;LD (HL),0
       ;congratulations
       ;JP BEGIN
dEBMALOG
;1
       IF msx
        CP IDdoska
        jr NZ,msxNdoska
        PUSH HL
        LD L,(IX+2)
        LD H,(IX+3)
        DEC HL,HL,HL,HL
        LD (IX+3),H
        LD (IX+2),L
        POP HL
msxNdoska
       ENDIF 
       IF byting
        EXX 
        LD A,B ;номер стенки
        EXX 
       ELSE 
        LD A,wallcode
       ENDIF 
dEBMALU DEC L,L
        LD B,4
        CALL PUTBMAP
        INC L
        DJNZ $-4
        RET 
dEBMAVER
       IF byting
        EXX 
        LD A,B ;номер стенки
        EXX 
       ELSE 
        LD A,wallcode
       ENDIF 
dEBMAVU ;DEC L,L
        LD B,4
        CALL PUTBMAP
        DEC C
        DJNZ $-4
        RET 
PUTBMAP
      ;в байте 4 клетки (по вертикали: 11223344)
    ;A=комбинация:
      ;00-пусто
      ;01-враг (?)
      ;10-бонус
      ;11-стена
       IF byting
       PUSH HL
       PUSH AF
        LD A,C
        RRA 
        RRA 
        AND #0F
        ADD A,BMAP/256
        LD H,A
        LD A,C
        AND 3
        RRCA 
        RRCA 
        OR L
        LD L,A
       POP AF
        LD (HL),A
       POP HL
       ELSE 
       PUSH BC
       PUSH AF
        LD A,C
        RRA 
        RRA 
        AND #0F
        ADD A,BMAP/256
        LD H,A
        LD A,C
        AND 3
        INC A
        LD B,A ;1,2,3,4
       POP AF
       PUSH AF
       ;LD A,wallcode
        RRCA 
        RRCA 
        DJNZ $-2
        OR (HL)
        LD (HL),A
       POP AF
       POP BC
       ENDIF 
        RET 
ADLEDIV16
        LD A,D
        ld L,E
       DUP 4
        SRL B
        RR C
        RRA 
        RR L
       EDUP 
        RET 
dEBMAPP
        INC HL,HL
        LD C,(HL) ;
        INC HL
        LD B,(HL) ;Y
        INC HL
        LD E,(HL) ;
        INC HL
        LD D,(HL) ;X
         ;для доски
         DEC BC
         LD A,C
         OR 15
         LD C,A
        CALL ADLEDIV16
         INC C ;для доски
        RET 
DIGtoDE
        LD B,"0"-1
        INC B
        SUB C
        jr NC,$-2
        ADD A,C
        EX de,hl 
        LD (HL),B
        EX de,hl 
        INC DE
        RET 
       if 1
curscrXOR8=changescrpg
        ;LD HL,curscr
        ;LD A,(HL)
        ;XOR 8
        ;LD (HL),A
        ;RET
       endif
RLLDIR32
        PUSH HL
        LD BC,32
        LDIR 
        POP DE
        LD H,D
        ld L,E
        RET 

;----depk таблицу коллизий и установить keys
depklevel
       LD A,pgbmap
       CALL OUTA
        LD IX,HEROES;-Lunit
        LD HL,BMAP
        LD DE,BMAP+1
        LD BC,#0FFF
        LD (HL),L
        LDIR 
      ;LD BC,0
       EXX 
dEBMAP0
       EXX 
       INC B
       EXX 
        LD DE,Lunit
        ADD IX,DE
        LD A,(IX)
        OR A
        jr Z,dEBMAPQ
       PUSH IX
       POP HL
        CALL dEBMAPP
       LD A,(IX)
       CP IDapple
       jr C,dEBMAP0
       CP IDlog
       jr C,dEBMAPapp
       CP IDlogV
       jr C,dEBMAPlog
          ;вер.стены
        CALL dEBMAVER
        JR dEBMAP0
dEBMAPlog ;гор.стены
        CALL dEBMALOG
        JR dEBMAP0
dEBMAPapp
       CP IDkey
       jr NZ,dEBnKEY
        EXX 
        INC C
        EXX 
dEBnKEY
        LD A,%10
        CALL PUTBMAP
        INC L
        CALL PUTBMAP
        DEC C
        CALL PUTBMAP
        DEC L
        CALL PUTBMAP
        JR dEBMAP0
dEBMAPQ
    ;----
        EXX 
        LD A,C
        LD (keys),A
        call INVALIDATEKEYS
        ret
