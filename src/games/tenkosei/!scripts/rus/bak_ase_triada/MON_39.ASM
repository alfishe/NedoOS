        include SUPER_C.inc
M_START:
MON_39
	FLG_IF JUMP,'=',72,FF_3
	FLG_IF JUMP,'=',71,FF_2
	FLG_IF JUMP,'=',70,FF_1
	BAK_INIT	'tb_001a',B_NORM
	CDPLAY	12
	DB "Кенджиру:  *Ааа*  О, я выспался..."
	DB	NEXT
	DB "Оденусь и пойду завтракать."
	DB	NEXT
	DB "Я надеваю форму и спускаюсь в кухню."
	DB	NEXT
	BAK_INIT	'tb_002',B_NORM
	CDPLAY	6
	T_CG	'tt_20_02',AKE_A2,0
	DB "Кенджиру:  Привет."
	DB	NEXT
	DB "Акеми:  Привет."
	DB	NEXT
	DB "Мотоки не видно на кухне."
	DB	NEXT
	DB "Кенджиру:  Акеми-сан, где Мотока?"
	DB	NEXT
	DB "Акеми:  Она уже пощла в школу. Сказала, что встречается с другом или типа тогою."
	DB	NEXT
	DB "Кенджиру:  Да."
	DB	NEXT
	DB "Акеми: Ты хотел пойти в школу с ней?"
	DB	NEXT
	DB "Кенджиру:  Нет конечно! Я и не думал."
	DB	NEXT
	DB "Я закончил завтракать, И отправился в школу."
	DB	NEXT
	B_O	B_FADE,C_KURO
	CDPLAY	2
	BAK_INIT	'tb_006',B_NORM
	DB "Я остановился возле магазина, чтобы пообедать. Я всегда трачу меньше, чем 500 йен на обед."
	DB	NEXT
	BAK_INIT	'tb_007',B_NORM
	CDPLAY	3
	DB "В магазине я увидел Теруми, она читала журналы."
	DB	NEXT
	T_CG	'tt_05_07',TER2,0
	DB "Кенджиру:  Привет, Теруми-сенпай."
	DB	NEXT
	DB "Теруми:  Доброе утро. Пойдем в школу?" 
	DB	NEXT
	DB "Кенджиру:  А?" 
	DB	NEXT
	DB "Теруми:  Ты знаешь нашу школу?" 
	DB	NEXT
	DB "Кенджиру:  Хорошо, пойдем..."
	DB	NEXT
	DB "Я вышел из магазина с Теруми, при этом не забыв купить что-нибудь на обед."
	DB	NEXT
	F_O	B_NORM,C_KURO
	DB "Я пошел на метро и сел на поезд."
	DB	NEXT
	BAK_INIT	'tb_008',B_NORM
	T_CG	'tt_05_08',TER2,0
	DB "Теруми:  Четр, ненавижу следующую остановку. Вечно куча людей садится." 
	DB	NEXT
	DB "Кенджиру:  Ну да, это Япония."
	DB	NEXT
	DB "Поезд остановился, и двери открылись. Сразу же нахлынул поток людей."
	DB	NEXT
	DB "Теруми:  Вот они..."
	DB	NEXT
	DB "Людей было столько, что Теруми и я не могли и пошевелится."
	DB	NEXT
	F_O	B_NORM,C_KURO
	DB "Теруми:  Такого я еще не видел..."
	DB	NEXT
	DB "Кенджиру:  Да.Вот что приходится делать, чтобы не опаздывать."
	DB	NEXT
	DB "Теруми:  ...Да мне все равно опаздываю я или нет, лишь бы поезд был не так забит." 
	DB	NEXT
	DB "Кенджиру:  Да, да."
	DB	NEXT
	DB "Когда мы приблизились к нашей остановке, стало тише, так как люди готовились на выход."
	DB	NEXT
	DB "Теруми:  Ой!" 
	DB	NEXT
	DB "(Ой?)"
	DB	NEXT
	DB "Теруми  вскрикнула и попыталась отодвинуться."
	DB	NEXT
	DB "Я посмотрел на попку Теруми и увидел там мужскую руку."
	DB	NEXT
	DB "О, как печально. Даже Теруми лпают в поездах."
	DB	NEXT
	DB "Я знал, что она сделает."
	DB	NEXT
	DB "Но к моему удивлению, она только убрала руку и отодвинулась."
	DB	NEXT
	DB "Теруми:  Извращенцы..." 
	DB	NEXT
	DB "Кенджиру:  Что?"
	DB	NEXT
	DB "Из-за того, что вагон был забит, он не могла ничего поделать."
	DB	NEXT
	DB "Возможно я мог прикоснуться.."
	DB	NEXT
	DB "Медленно, я повернулся к извращенцу, так чтобы он не заметил меня."
	DB	NEXT
	DB "Кенджиру:  Эй!"
	DB	NEXT
	DB "Извращ:   Что?"
	DB	NEXT
	DB "Ухмыляясь, он отодвинулся от Теруми и расстворился в толпе."
	DB	NEXT
	DB "У него хорошо получалось,должно быть не впервые."
	DB	NEXT
	DB "Теруми:  Спасибо." 
	DB	NEXT
	DB "Кенджиру:  ...Теруми."
	DB	NEXT
	DB "Теруми:  ................." 
	DB	NEXT
	DB "Кенджиру:  Почему ты раньше не попросила помощи?"
	DB	NEXT
	DB "Теруми:  ....................." 
	DB	NEXT
	DB "Кенджиру:  ...Я совсем непригоден, что ты прямо меня не просила?"
	DB	NEXT
	DB "Теруми:  Не в этом дело.." 
	DB	NEXT
	DB "Кенджиру:  Знаешь, Я..."
	DB	T_WAIT,	3
	DB " Я тоже мужчина."
	DB	NEXT
	DB "Теруми:  Знаю. Я часто замечала..." 
	DB	T_WAIT,	3
	DB "Ты изменилась."
	DB	NEXT
	FLG_KI	TER_DEN,'=',1
	DB "Когда поезд приехал, двери открылись и поток людей вышел."
	DB	NEXT
	BAK_INIT	'tb_009',B_NORM
	CDPLAY	2
	DB "Кенджиру:  О, где Теруми?"
	DB	NEXT
	DB "Я огляделся, но ее не увидел."
	DB	NEXT
	DB "Думаю, она смылась."
	DB	NEXT
	DB "По крайней мере она могла подождать меня."
	DB	NEXT
	DB "Я иду в школу один."
	DB	NEXT
	B_O	B_FADE,C_KURO
	BAK_INIT	'tb_010',B_NORM
	CDPLAY	14
	T_CG	'tt_08_10',TET_A2,0
	DB "Тецуя:    Утро." 
	DB	NEXT
	DB "Кенджиру:  Утро."
	DB	NEXT
	DB "Тецуя:    Ты пришел один."
	DB	NEXT
	DB "Кенджиру:  Это ничего не значит."
	DB	NEXT
	DB "Тецуя:    Да? Интересно. О, Кашима-сан здесь."
	DB	NEXT
	DB "Ненавижу, когда он так смотрит на меня..."
	DB	NEXT
	DB "Тецуя:    В чем дело? Чего ты вдруг замолчала?"
	DB	NEXT
	DB "Кенджиру:  Ничего."
	DB	NEXT
	;WAV	'Se_ch'
	DB "Прозвучал звонок, означает начало урока."
	DB	NEXT
	DB "Кенджиру:  Я сяду."
	DB	NEXT
	DB "Тецуя:    Ага." 
	DB	NEXT
	TATI_ERS
	DB "Я сажусь."
	DB	NEXT
	F_O	B_NORM,C_KURO
	;;WAV  'STOP'
	CDPLAY		0
	DB "Я тупо смотрю на доску и думаю, зачем образование."
	DB	NEXT
	B_O	B_FADE,C_KURO
	FLG_KI	JUMP,'=',70
	SINARIO	'NITI_HIR.OVL'
FF_1:
	FLG_KI JUMP,'=',0
	FLG_KI	JUMP,'=',71
	SINARIO	'NITI_HOK.OVL'
FF_2:
	FLG_KI JUMP,'=',0
	BAK_INIT 'tb_018c',B_NORM
	CDPLAY	22
	DB "Уже был вечер, когда я вышел из школы. Солнце садилось."
	DB	NEXT
	DB "Я пойду домой."
	DB	NEXT
	FLG_KI JUMP,'=',72
	SINARIO	'NITI_KIT.OVL'
FF_3:
	FLG_KI JUMP,'=',0
	SINARIO 'MOM_40.OVL'
END
