        include SUPER_C.inc
M_START:
MON_47
	FLG_IF JUMP,'=',97,FF_4
	FLG_IF JUMP,'=',96,FF_3
	FLG_IF JUMP,'=',95,FF_2
	FLG_IF JUMP,'=',94,FF_1
	FLG_KI	HANAJI,'=',0
	BAK_INIT	'tb_001a',B_NORM
	CDPLAY	12
	DB	"Кэндзиро: *Зев* Хорошо поспал."
	DB	NEXT
	DB	"Пожалуй, спущусь вниз и позавтракаю."
	DB	NEXT
	DB	"Я переоделся и спустился на кухню."
	DB	NEXT
	BAK_INIT	'tb_002',B_NORM
	CDPLAY	9
	T_CG	'tt_10_02',MOT_A3,0
	T_CG	'tt_20_02',AKE_A1,0
	DB	"Мотока и Акэми здесь."
	DB	NEXT
	DB	"Мотока: Ониитян, доброе утро!" 
	DB	NEXT
	DB	"Акэми: А, Кэндзиро-кун. Доброе утро."
	DB	NEXT
	DB	"Кэндзиро: Доброе утро. Завтрак готов?"
	DB	NEXT
	DB	"Акэми: Да, только что."
	DB	NEXT
	DB	"Она ставит передо мной свежеподжаренный тост и горячий кофе."
	DB	NEXT
	TATI_ERS
	T_CG	'tt_10_02',MOT_A2,0
	DB	"После этого, она начинает свои домашние хлопоты."
	DB	NEXT
	DB	"Мотока: Ониитян?"
	DB	NEXT
	DB	"Кэндзиро: Да?"
	DB	NEXT
	DB	"Мотока: Хочешь, пойдём в школу вместе?"
	DB	NEXT
	DB	"Я наконец-то помирился с Мотокой, так что лучше всего будет, если я пойду с ней в школу."
	DB	NEXT
	DB	"Кэндзиро: Конечно, пошли вместе."
	DB	NEXT
	DB	"Мотока: Здорово!" 
	DB	NEXT
	DB	"Я иду в школу с Мотокой."
	DB	NEXT
	F_O	B_NORM,C_KURO
	CDPLAY	0
	DB	"Я покупаю себе обед в магазине и сажусь на поезд."
	DB	NEXT
	DB	"В поезде довольно много народа, все толкают друг друга во время езды."
	DB	NEXT
	BAK_INIT	'tb_009',B_NORM
	CDPLAY	9
	T_CG	'tt_10_09',MOT_A2,0
	DB	"Кэндзиро: Мотока, как ты? В поезде было довольно тесно. Тебя никто не пытался потрогать?"
	DB	NEXT
	DB	"Мотока: Нет, всё нормально. А что?" 
	DB	NEXT
	DB	"Кэндзиро: О, ты же знаешь, что в часы пик там полно таких людей. Будь осторожна."
	DB	NEXT
	DB	"Мотока: Всё будет хорошо. Со мной такого никогда не случалось." 
	DB	NEXT
	DB	"Кэндзиро: Потому что ты ещё девочка."
	DB	NEXT
	DB	"Мотока: Хммф! Я уже не девочка." 
	DB	NEXT
	FLG_IF MOT_YATT,'!=',1,TUJO
	DB	"Кэндзиро: Шшш! Не говори слишком громко."
	DB	NEXT
	DB	"Мотока: ..................." 
	DB	NEXT
	DB	"Её лицо стало ярко-красным."
	DB	NEXT
	DB	"Мотока: Ониитян, ты такой извращенец..." 
	DB	T_WAIT,	3
	DB	" Я не это имела в виду."
	DB	NEXT
	DB	"Кэндзиро: Э? О, ладно."
	DB	NEXT
	DB	"Сихо: Кэндзиро-кун, доброе утро." 
	DB	NEXT
	TATI_ERS
	T_CG	'tt_10_09',MOT_A3,0
	T_CG	'tt_02_09',SIH_A1,0
	DB	"Мотока: А, доброе утро." 
	DB	NEXT
	DB	"Сихо: Э? Доброе утро." 
	DB	NEXT
	DB	"Сихо не смогла скрыть удивления от приветствия Мотоки."
	DB	NEXT
	GO	TUJO2
TUJO:
	DB	"Кэндзиро: Э? То есть, ты не девственница..."
	DB	NEXT
	DB	"Мотока: О-ониитян, ты извращенец!" 
	DB	NEXT
	DB	"Лицо Мотоки стало ярко-красным. Последние слова она так прокричала, что все на нас посмотрели."
	DB	NEXT
	DB	"Мотока: Я не это имела в виду!" 
	DB	NEXT
	DB	"Я просто... Я имела в виду, что стала более... более взрослой."
	DB	NEXT
	DB	"Кэндзиро: В-верно. Извини."
	DB	NEXT
	DB	"Сихо: Кэндзиро-кун, доброе утро." 
	DB	NEXT
	CDPLAY	11
	T_CG	'tt_02_09',SIH_A1,0
	DB	"О нет! Сейчас будет ещё одна кровавая сцена!.."
	DB	NEXT
	DB	"Мотока: А, доброе утро." 
	DB	NEXT
	DB	"Возможно, чувствуя себя неловко, Мотока нормально поприветствовала Сихо."
	DB	NEXT
	DB	"Сихо: А, доброе утро." 
	DB	NEXT
	DB	"Сихо не смогла скрыть удивления от доброго приветствия Мотоки."
	DB	NEXT
TUJO2:
	DB	"Сихо: Хороший сегодня денёк." 
	DB	NEXT
	DB	"Мотока: Правда?"
	DB	NEXT
	DB	"Мотока: Минуточку. Касима-сэмпай, твоя форма, она же прошлогодняя. В апреле ввели форму нового образца."
	DB	NEXT
	DB	"Сихо: Э?" 
	DB	NEXT
	DB	"Мотока: Откуда у тебя прошлогодняя форма?"
	DB	NEXT
	DB	"Сихо: ................" 
	DB	NEXT
	DB	"Если подумать, у неё та же форма, что и у остальных в классе, хотя она перевелась недавно, и у неё должна быть новая."
	DB	NEXT
	DB	"Сихо: О, у них ещё осталась старая форма, так что я взяла одну из них." 
	DB	NEXT
	DB	"Мотока: Клёво. Старая форма мне больше нравилась."
	DB	NEXT
	DB	"Но я был уверен, что от всей старой формы избавились в прошлом году?.."
	DB	NEXT
	DB	"Мотока: Ониитян, что случилось?" 
	DB	NEXT
	DB	"Кэндзиро: Ничего. Я просто витал в облаках." 
	DB	NEXT
	DB	"Мотока: О. Он часто так делает, не так ли, Касима-сэмпай?" 
	DB	NEXT
	DB	"Сихо: ...Да, часто." 
	DB	NEXT
	DB	"Хмм, раньше я даже избегал Сихо..."
	DB	T_WAIT,	3
	DB	" Хмм, просто я не понимаю женщин."
	DB	NEXT
	DB	"Сихо: Ну что, пойдём?"
	DB	NEXT
	DB	"Кэндзиро: Ага, пошли."
	DB	NEXT
	DB	"Сегодня, Мотока, Сихо и я шли в школу все вместе."
	DB	NEXT
	FLG_KI	SEIFUKU,'=',1
	BAK_INIT 'tb_010',B_NORM
	CDPLAY	23
	T_CG 'tt_02_10',SIH_A3,0
	T_CG 'tt_08_10',TET_A1,0
	DB	"Тэцуя: Доброе утро, Касима-сан." 
	DB	NEXT
	DB	"Сихо: Доброе утро."
	DB	NEXT
	DB	"Кэндзиро: Минуточку..."
	DB	T_WAIT, 5
	DB	" А как же я?"
	DB	NEXT
	DB	"Тэцуя: О, Кэндзиро, и ты здесь."
	DB	NEXT
	DB	"Кэндзиро: Эй..."
	DB	NEXT
	DB	"И тут прозвенел звонок."
	DB	NEXT
	;WAV		'Se_ch'
	DB	"Сихо: Наверное, тебе надо сесть."
	DB	NEXT
	DB	"Тэцуя: Ты права."
	DB	NEXT
	TATI_ERS
	DB	"Кэндзиро: Я тоже сяду."
	DB	NEXT
	F_O	B_NORM,C_KURO
	CDPLAY		0
	DB	"Я апатично гляжу на доску, размышляя о том, какая польза от образования."
	DB	NEXT
	B_O	B_FADE,C_KURO
	B_O	B_FADE,C_KURO
	FLG_KI JUMP,'=',94
	SINARIO 'NITI_HIR.OVL'
FF_1:
	FLG_KI JUMP,'=',0
	FLG_KI JUMP,'=',95
	SINARIO 'NITI_HOK.OVL'
FF_2:
	FLG_KI JUMP,'=',0
	FLG_KI JUMP,'=',96
	SINARIO 'NITI_MAT.OVL'
FF_3:
	FLG_KI JUMP,'=',0
	FLG_IF	HANAJI,'=',1,OYASUMI
	FLG_KI JUMP,'=',97
	SINARIO 'NITI_KIT.OVL'
FF_4:
	FLG_KI JUMP,'=',0
	SINARIO	'MON_48.OVL'
	DB	EXIT
OYASUMI:
	FLG_KI JUMP,'=',0
	FLG_KI	HANAJI,'=',0
	SINARIO	'MON_48.OVL'
	DB	EXIT
END