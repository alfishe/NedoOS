        include SUPER_C.inc
M_START:
MON_39
	FLG_IF JUMP,'=',72,FF_3
	FLG_IF JUMP,'=',71,FF_2
	FLG_IF JUMP,'=',70,FF_1
	BAK_INIT	'tb_001a',B_NORM
	CDPLAY	12
	DB	"Кэндзиро: *Зев* Ах, хорошо поспал..."
	DB	NEXT
	DB	"Пожалуй, оденусь и пойду завтракать."
	DB	NEXT
	DB	"Я надеваю школьную форму, и спускаюсь на кухню."
	DB	NEXT
	BAK_INIT	'tb_002',B_NORM
	CDPLAY	6
	T_CG	'tt_20_02',AKE_A2,0
	DB	"Кэндзиро: Доброе утро."
	DB	NEXT
	DB	"Акэми: Доброе утро."
	DB	NEXT
	DB	"Мотоки на кухне нигде не видно."
	DB	NEXT
	DB	"Кэндзиро: Акэми-сан, где Мотока?"
	DB	NEXT
	DB	"Акэми: Она уже ушла в школу. Она сказала, что с кем-то из друзей встретится."
	DB	NEXT
	DB	"Кэндзиро: Понятно."
	DB	NEXT
	DB	"Акэми: Ты хотел пойти в школу с ней?"
	DB	NEXT
	DB	"Кэндзиро: Н-нет, конечно! Я ничего такого не имел в виду."
	DB	NEXT
	DB	"Я закончил завтракать, и отправился в школу."
	DB	NEXT
	B_O	B_FADE,C_KURO
	CDPLAY	2
	BAK_INIT	'tb_006',B_NORM
	DB	"Я остановился у магазина, чтобы купить обед. Как всегда укладываюсь в 500 иен."
	DB	NEXT
	BAK_INIT	'tb_007',B_NORM
	CDPLAY	3
	DB	"В углу магазина Тэруми-сэмпай читает журналы."
	DB	NEXT
	T_CG	'tt_05_07',TER2,0
	DB	"Кэндзиро: Доброе утро, Тэруми-сэмпай."
	DB	NEXT
	DB	"Тэруми: Доброе утро. Пошли в школу?" 
	DB	NEXT
	DB	"Кэндзиро: Э?" 
	DB	NEXT
	DB	"Тэруми: Знаешь, в нашу школу?" 
	DB	NEXT
	DB	"Кэндзиро: Л-ладно, пошли..."
	DB	NEXT
	DB	"Я вышел из магазина вместе с Тэруми-сэмпай, не забыв купить обед."
	DB	NEXT
	F_O	B_NORM,C_KURO
	DB	"Я пошёл на станцию и сел на поезд."
	DB	NEXT
	BAK_INIT	'tb_008',B_NORM
	T_CG	'tt_05_08',TER2,0
	DB	"Тэруми: Проклятье, ненавижу следующую станцию. В поезд всегда заходит масса людей." 
	DB	NEXT
	DB	"Кэндзиро: Да, что ж, мы в Японии."
	DB	NEXT
	DB	"Поезд остановился, и двери открылись. На нас тут же понёсся поток людей."
	DB	NEXT
	DB	"Тэруми: Вот они..."
	DB	NEXT
	DB	"Напор толпы был таким сильным, что нас с Тэруми захватило в неё, без какой-либо возможности пошевелиться."
	DB	NEXT
	F_O	B_NORM,C_KURO
	DB	"Тэруми: Э-это худшее, что я когда-либо видела..."
	DB	NEXT
	DB	"Кэндзиро: Да. То, что мы делаем, чтобы не опоздать в школу."
	DB	NEXT
	DB	"Тэруми: ...Мне пофиг на опоздание, если бы в поезде было поменьше народа." 
	DB	NEXT
	DB	"Кэндзиро: Да, да."
	DB	NEXT
	DB	"Приближаясь к нашей остановке, поезд становился всё тише и тише, люди готовились выходить."
	DB	NEXT
	DB	"Тэруми: Кьа!" 
	DB	NEXT
	DB	"(Кьа?)"
	DB	NEXT
	DB	"Тэруми-сэмпай взвизгнула, и попыталась пошевелиться."
	DB	NEXT
	DB	"Я смотрю вниз и вижу мужскую руку, ощупывающую Тэруми-сэмпай."
	DB	NEXT
	DB	"Ох, как грустно. Даже Тэруми-сэмпай лапают в поезде."
	DB	NEXT
	DB	"Я знал, что она сделает дальше."
	DB	NEXT
	DB	"Но, к моему удивлению, она только оттолкнула его руку и отодвинулась."
	DB	NEXT
	DB	"Тэруми: Проклятые извращенцы..." 
	DB	NEXT
	DB	"Кэндзиро: А?"
	DB	NEXT
	DB	"Поскольку поезд был так переполнен, она не смогла освободить руки, чтобы что-нибудь сделать."
	DB	NEXT
	DB	"Наверное, я мог бы дотянуться..."
	DB	NEXT
	DB	"Медленно, я двигаюсь к извращенцу, осторожно, так что он этого не замечает."
	DB	NEXT
	DB	"Кэндзиро: Эй!"
	DB	NEXT
	DB	"Извращенец: Чё?"
	DB	NEXT
	DB	"С циничной усмешкой он отодвинулся от Тэруми, и растворился в толпе."
	DB	NEXT
	DB	"Он знает в этом толк. Должно быть, не в первый раз."
	DB	NEXT
	DB	"Тэруми: ...Спасибо." 
	DB	NEXT
	DB	"Кэндзиро: ...Тэруми-сэмпай."
	DB	NEXT
	DB	"Тэруми: ................." 
	DB	NEXT
	DB	"Кэндзиро: Почему ты до этого не попросила меня помочь?"
	DB	NEXT
	DB	"Тэруми: ....................." 
	DB	NEXT
	DB	"Кэндзиро: ...Я так бесполезен, что ты не могла прямо попросить?"
	DB	NEXT
	DB	"Тэруми: Это не так..." 
	DB	NEXT
	DB	"Кэндзиро: Знаешь, я..."
	DB	T_WAIT,	3
	DB	" Я тоже мужчина."
	DB	NEXT
	DB	"Тэруми: Знаю. Я часто это замечаю..." 
	DB	T_WAIT,	3
	DB	"В последнее время ты изменился."
	DB	NEXT
	FLG_KI	TER_DEN,'=',1
	DB	"И тут поезд остановился на нашей станции, двери открылись, выпуская всех на платформу."
	DB	NEXT
	BAK_INIT	'tb_009',B_NORM
	CDPLAY	2
	DB	"Кэндзиро: А? Где Тэруми-сэмпай?"
	DB	NEXT
	DB	"Я оглядываюсь, но нигде её не вижу."
	DB	NEXT
	DB	"Думаю, её унесло потоком людей."
	DB	NEXT
	DB	"Но в таком случае, по крайней мере, могла бы меня подождать."
	DB	NEXT
	DB	"Я иду в школу один."
	DB	NEXT
	B_O	B_FADE,C_KURO
	BAK_INIT	'tb_010',B_NORM
	CDPLAY	14
	T_CG	'tt_08_10',TET_A2,0
	DB	"Тэцуя: Доброе утро." 
	DB	NEXT
	DB	"Кэндзиро: Доброе."
	DB	NEXT
	DB	"Тэцуя: Ты сегодня один."
	DB	NEXT
	DB	"Кэндзиро: Это ничего не значит."
	DB	NEXT
	DB	"Тэцуя: Серьёзно? Интересно. О, Касима-сан здесь."
	DB	NEXT
	DB	"Ненавижу, когда он так говорит..."
	DB	NEXT
	DB	"Тэцуя: Что случилось? Почему ты вдруг так затих?"
	DB	NEXT
	DB	"Кэндзиро: Ничего."
	DB	NEXT
	;WAV	'Se_ch'
	DB	"Звенит звонок, объявляя начало уроков."
	DB	NEXT
	DB	"Кэндзиро: Пожалуй, пойду сяду."
	DB	NEXT
	DB	"Тэцуя: Угу." 
	DB	NEXT
	TATI_ERS
	DB	"Я сажусь на место."
	DB	NEXT
	F_O	B_NORM,C_KURO
	;WAV  'STOP'
	CDPLAY		0
	DB	"Я тупо смотрю на доску и размышляю о смысле учёбы."
	DB	NEXT
	B_O	B_FADE,C_KURO
	FLG_KI	JUMP,'=',70
	SINARIO	'NITI_HIR.OVL'
FF_1:
	FLG_KI JUMP,'=',0
	FLG_KI	JUMP,'=',71
	SINARIO	'NITI_HOK.OVL'
FF_2:
	FLG_KI JUMP,'=',0
	BAK_INIT 'tb_018c',B_NORM
	CDPLAY	22
	DB	"Когда я вышел из школы, был уже вечер, и солнце скрылось за горизонтом."
	DB	NEXT
	DB	"Пожалуй, сегодня пойду домой."
	DB	NEXT
	FLG_KI JUMP,'=',72
	SINARIO	'NITI_KIT.OVL'
FF_3:
	FLG_KI JUMP,'=',0
	SINARIO 'MOM_40.OVL'
END