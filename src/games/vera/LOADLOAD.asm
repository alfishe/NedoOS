;Загрузчик загрузчика :)
;игры Вера (в Бейсик строке)

PG_SPR  EQU 0 ;спрайты 2*2 512 штук
PG_MAP  EQU 1 ;карта,массив,путь,скрипты,звуки
PG_MISC EQU 3 ;распак. текст,ключевой кадр, упак.карта,массив
PG_HERO EQU 4 ;спрайты героя
PG_MUZ  EQU 6 ;Плеер,музыка
PG_VIEW EQU 7 ;упак. экран

        ORG #6000

        DISP 23872

        DB 16,7,17,7
        DB "SETUP"
SETUP   DB 1 ;мышь
        DB 1 ;колесо
        DB 0 ;джойстик
        DB 1 ;клавиатура
        DB 0 ;ускорение курсора
        DB 1 ;музыка
        DB 1 ;звуки


LOADER
        LD HL,#5800
        LD DE,#5801
        LD BC,767
        LD (HL),L
        LDIR 
        LD HL,#4000
        PUSH HL
        LD DE,(#5CF4)
        LD BC,#1705
        JP #3D13

        ENT 

        DISPLAY "Длина загрузчика ",$-#6000
        DISPLAY /A,/T,SETUP
