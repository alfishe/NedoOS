        ORG #6000

;Вывод спрайта солнца
SUNPR   LD DE,SUN
        LD HL,#4013
        LD C,12*8
SPS     CALL LDI13
        CALL LINE_HL
        DEC C
        JR NZ,SPS

;Вывод атрибутов
        LD HL,#5813
        LD C,12
SPS1    CALL LDI13
        CALL HL32
        DEC C
        JR NZ,SPS1
        RET 

LDI13   LD B,13
        PUSH HL
LDILP   LD A,(DE)
        LD (HL),A
        INC L
        INC DE
        DJNZ LDILP
        POP HL
        RET 

HL32    PUSH DE
        LD DE,32
        ADD HL,DE
        POP DE
        RET 

;На строку ниже в экранном файле
LINE_HL INC     H
        LD      A,H
        AND     7
        RET     NZ
        LD      A,L
        ADD     A,32
        LD      L,A
        RET     C
        LD      A,H
        SUB     8
        LD      H,A
        RET 

SUN
+       INCBIN "SUNSPR3.C"
