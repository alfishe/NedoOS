;L_5C3A = #5C3A

L_FF32=0xFF32 ;jp 61ab
;
DepackCastle
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_80D5	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_8114
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_80EF	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_8109
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_8109	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_80EF
	POP	HL
	JR	L_80D5
;
L_8114	AND	#7F
	JR	Z,L_8135
	INC	HL
	BIT	6,A
	JR	NZ,L_8127
	LD	B,A
L_811E	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_811E
	JR	L_80D5
;
L_8127	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_812D	CALL	L_74A6
	DJNZ	L_812D
	INC	HL
	JR	L_80D5
;
L_8135	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#8A       ;.....YI.
       DB       #00,#7C,#72,#7C,#72,#72,#7C,#00       ;.|r|rr|.
       DB       #00,#7F,#C2,#1C,#83,#00,#00,#1E       ;..B.....
       DB       #C1,#2E,#82,#7E,#42,#D5,#00,#83       ;A..~BU..
       DB       #FF,#00,#FF,#00,#03,#08,#04,#10       ;........
       DB       #05,#83,#FF,#00,#3C,#C1,#72,#83       ;....<Ar.
       DB       #3C,#00,#00,#00,#45,#10,#48,#28       ;<...E.H(
       DB       #10,#D4,#00,#70,#40,#81,#3E,#C2       ;.T.p@.>B
       DB       #4E,#38,#6F,#82,#7C,#70,#18,#90       ;N8o.|p..
       DB       #D4,#00,#70,#80,#C2,#75,#84,#3E       ;T.p.Bu.>
       DB       #00,#00,#3E,#C1,#70,#00,#08,#08       ;..>Ap...
       DB       #CE,#82,#70,#70,#D6,#00,#78,#80       ;N.ppV.x.
       DB       #81,#70,#00,#2F,#00,#40,#29,#00       ;.p./.@).
       DB       #28,#C8,#D4,#00,#71,#00,#28,#B0       ;(HT.q.(0
       DB       #01,#08,#88,#7E,#72,#72,#00,#00       ;...~rr..
       DB       #71,#7B,#75,#C0,#71,#D6,#00,#79       ;q{u@qV.y
       DB       #00,#20,#B8,#69,#08,#D4,#00,#71       ;. 8i.T.q
       DB       #80,#29,#B8,#29,#B1,#79,#C0,#79       ;.)8)1y@y
       DB       #C0,#50,#C0,#22,#00,#29,#78,#79       ;@P@".)xy
       DB       #40,#7A,#00,#7A,#00,#39,#F8,#29       ;@z.z.9x)
       DB       #08,#D4,#00,#72,#40,#2A,#69,#2A       ;.T.r@*i*
       DB       #08,#12,#48,#78,#40,#7A,#80,#61       ;..Hx@z.a
       DB       #40,#81,#70,#39,#88,#7A,#80,#7A       ;@.p9.z.z
       DB       #C0,#71,#00,#2A,#48,#11,#C7,#78       ;@q.*H.Gx
       DB       #C0,#7B,#00,#62,#40,#84,#72,#72       ;@{.b@.rr
       DB       #76,#7A,#0A,#00,#7B,#00,#7B,#40       ;vz..{.{@
       DB       #59,#80,#1A,#B0,#2A,#38,#7A,#40       ;Y..0*8z@
       DB       #2B,#8B,#83,#03,#0F,#3F,#03,#7E       ;+....?.~
       DB       #7B,#00,#1B,#00,#4B,#B1,#82,#18       ;{...K1..
       DB       #18,#78,#3C,#81,#3F,#C2,#FF,#7B       ;.x<.?B.{
       DB       #C0,#28,#B8,#28,#C0,#7B,#F9,#28       ;@(8(@{y(
       DB       #3C,#78,#40,#7B,#C0,#78,#B4,#38       ;<x@{@x48
       DB       #3C,#14,#32,#89,#3E,#55,#69,#51       ;<.2.>UiQ
       DB       #6B,#41,#49,#41,#61,#C0,#41,#82       ;kAIAa@A.
       DB       #51,#41,#03,#B8,#7C,#30,#78,#78       ;QA.8|0xx
       DB       #04,#70,#81,#BF,#04,#74,#81,#FB       ;.p.?.t.{
       DB       #04,#7B,#81,#3F,#C0,#7F,#8B,#7B       ;.{.?@..{
       DB       #7F,#7E,#7F,#56,#7D,#6B,#5D,#6A       ;.~.V}k]j
       DB       #55,#3F,#3B,#F8,#79,#2C,#48,#79       ;U?;xy,Hy
       DB       #00,#3B,#82,#FF,#FE,#14,#B7,#8D       ;.;..~.7.
       DB       #ED,#7E,#F5,#AA,#5D,#AA,#D5,#A2       ;m~u*]*U"
       DB       #55,#A8,#55,#80,#48,#02,#7F,#2A       ;U(U.H..*
       DB       #38,#79,#2C,#40,#B9,#08,#3B,#04       ;8y,@9.;.
       DB       #F5,#92,#F7,#FF,#00,#FE,#55,#A9       ;u.w..~U)
       DB       #11,#AB,#41,#89,#01,#A1,#01,#41       ;.+A..!.A
       DB       #01,#11,#01,#FE,#01,#6C,#82,#3C       ;...~.l.<
       DB       #18,#41,#70,#60,#F0,#81,#F7,#18       ;.Ap`p.w.
       DB       #36,#08,#7B,#81,#EF,#00,#BE,#82       ;6.{.o.>.
       DB       #FD,#EF,#78,#C0,#79,#A4,#20,#AF       ;}ox@y$ /
       DB       #08,#EF,#83,#FD,#FF,#DF,#00,#B7       ;.o.}._.7
       DB       #8A,#FE,#B5,#FA,#7D,#FA,#FD,#7A       ;.~5z}z}z
       DB       #F7,#BA,#ED,#78,#C0,#79,#A4,#0D       ;w:mx@y$.
       DB       #99,#8E,#DF,#FD,#FE,#FF,#EE,#FF       ;.._}~.n.
       DB       #FA,#BD,#EA,#5D,#AA,#55,#AA,#DD       ;z=j]*U*]
       DB       #00,#04,#83,#7D,#EA,#55,#00,#0A       ;...}jU..
       DB       #82,#55,#BE,#78,#C0,#32,#1C,#81       ;.U>x@2..
       DB       #FD,#05,#D6,#8A,#7F,#FD,#F6,#FF       ;}.V..}v.
       DB       #6E,#FD,#F6,#FD,#BB,#D5,#08,#2E       ;n}v};U..
       DB       #83,#BA,#D5,#EA,#08,#3C,#81,#57       ;.:Uj.<.W
       DB       #08,#3A,#81,#AA,#10,#12,#81,#EA       ;.:.*...j
       DB       #71,#80,#32,#1C,#81,#F7,#00,#40       ;q.2..w.@
       DB       #85,#B5,#EB,#55,#AA,#75,#10,#68       ;.5kU*u.h
       DB       #08,#06,#82,#D5,#BA,#10,#74,#10       ;...U:.t.
       DB       #3E,#00,#40,#81,#A8,#00,#82,#81       ;>.@.(...
       DB       #22,#71,#80,#82,#FB,#7F,#00,#AA       ;"q..{..*
       DB       #83,#B5,#EA,#D7,#00,#38,#81,#D5       ;.5jW.8.U
       DB       #00,#6A,#10,#3E,#18,#AC,#08,#B0       ;.j.>.,.0
       DB       #81,#8A,#28,#42,#81,#51,#18,#4A       ;..(B.Q.J
       DB       #81,#AE,#71,#80,#97,#AA,#54,#A8       ;..q..*T(
       DB       #74,#A8,#55,#A2,#54,#AA,#50,#A8       ;t(U"T*P(
       DB       #12,#A8,#54,#A8,#44,#A8,#50,#A8       ;.(T(D(P(
       DB       #52,#A0,#54,#88,#08,#EE,#88,#54       ;R T..n.T
       DB       #AA,#45,#AA,#15,#AA,#51,#A8,#01       ;*E*.*Q(.
       DB       #EA,#00,#0C,#08,#44,#82,#15,#AA       ;j...D..*
       DB       #7A,#40,#81,#40,#16,#EA,#82,#02       ;z@.@.j..
       DB       #80,#26,#F1,#82,#80,#02,#06,#FA       ;.&q....z
       DB       #85,#40,#00,#10,#A0,#00,#10,#12       ;.@.. ...
       DB       #85,#20,#02,#00,#80,#10,#00,#16       ;. ......
       DB       #85,#08,#80,#40,#80,#52,#00,#C2       ;...@.R.B
       DB       #7A,#40,#0F,#29,#00,#22,#27,#30       ;z@.)."'0
       DB       #08,#3E,#1F,#3B,#18,#58,#40,#20       ;.>.;.X@ 
       DB       #85,#80,#01,#00,#40,#B7,#7A,#40       ;....@7z@
       DB       #DE,#00,#38,#5D,#83,#00,#00,#FE       ;^.8]...~
       DB       #7B,#00,#EA,#00,#91,#FB,#00,#FE       ;{.j..{.~
       DB       #ED,#7F,#F5,#AB,#5D,#AB,#D5,#A3       ;m.u+]+U#
       DB       #55,#A9,#55,#81,#49,#FE,#17,#C7       ;U)U.I~.G
       DB       #24,#1A,#57,#D8,#78,#18,#60,#18       ;$.WXx.`.
       DB       #CD,#FF,#78,#40,#78,#58,#81,#00       ;M.x@xX..
       DB       #D8,#FF,#81,#00,#78,#80,#78,#98       ;X...x.x.
       DB       #70,#80,#81,#C7,#78,#C0,#78,#C0       ;p..Gx@x@
       DB       #81,#00,#78,#D8,#CF,#FF,#79,#00       ;..xXO.y.
       DB       #79,#18,#81,#00,#D8,#FF,#79,#40       ;y...X.y@
       DB       #79,#58,#81,#00,#D8,#FF,#79,#80       ;yX..X.y.
       DB       #79,#98,#81,#00,#D8,#FF,#81,#00       ;y...X...
       DB       #79,#C0,#79,#D8,#D8,#FF,#7A,#00       ;y@yXX.z.
       DB       #7A,#18,#81,#00,#4D,#13,#86,#FE       ;z...M..~
       DB       #FC,#F8,#F0,#E0,#C0,#7A,#40,#7A       ;|xp`@z@z
       DB       #40,#81,#00,#4A,#58,#10,#38,#81       ;@..JX.8.
       DB       #C0,#2B,#6F,#7A,#80,#7A,#80,#5F       ;@+oz.z._
       DB       #F0,#CC,#00,#7A,#C0,#7A,#C0,#81       ;pL.z@z@.
       DB       #00,#4A,#D8,#83,#7F,#1F,#03,#C9       ;.JX....I
       DB       #00,#7B,#00,#7B,#00,#81,#00,#6B       ;.{.{...k
       DB       #18,#83,#1F,#0F,#01,#C5,#00,#7B       ;.....E.{
       DB       #40,#7B,#40,#81,#00,#7B,#58,#C0       ;@{@..{X@
       DB       #FF,#86,#7F,#7F,#3F,#1F,#07,#01       ;....?...
       DB       #7B,#80,#7B,#80,#81,#00,#7B,#98       ;{.{...{.
       DB       #CF,#FF,#81,#00,#7B,#C0,#7B,#D8       ;O...{@{X
       DB       #D8,#FF,#7C,#00,#7C,#18,#5C,#00       ;X.|.|.\.
       DB       #82,#FE,#FC,#02,#02,#6F,#90,#85       ;.~|..o..
       DB       #3F,#6D,#7E,#75,#6A,#07,#9A,#88       ;?m~uj...
       DB       #62,#55,#68,#55,#40,#48,#3F,#00       ;bUhU@H?.
       DB       #7C,#58,#10,#3A,#82,#F8,#E0,#25       ;|X.:.x`%
       DB       #71,#6F,#90,#6F,#60,#78,#60,#58       ;qo.o`x`X
       DB       #60,#78,#30,#5F,#60,#81,#FF,#78       ;`x0_`..x
       DB       #60,#78,#60,#78,#30,#78,#90,#78       ;`x`x0x.x
       DB       #90,#17,#C0,#5D,#50,#78,#C0,#78       ;..@]Px@x
       DB       #90,#5F,#C0,#81,#3F,#07,#4C,#92       ;._@.?.L.
       DB       #7E,#7D,#7A,#7C,#6D,#78,#79,#7A       ;~}z|mxyz
       DB       #79,#7A,#79,#5A,#79,#7A,#78,#7A       ;yzyZyzxz
       DB       #78,#7A,#C0,#78,#81,#69,#C1,#78       ;xz@x.iAx
       DB       #81,#7F,#79,#20,#67,#C0,#8C,#FF       ;..y g@..
       DB       #D5,#BA,#D5,#FF,#80,#14,#A9,#54       ;U:U...)T
       DB       #A0,#00,#88,#2E,#CD,#33,#5D,#01       ; ...M3].
       DB       #7E,#79,#50,#60,#C0,#88,#55,#8B       ;~yP`@.U.
       DB       #51,#A9,#C3,#29,#11,#15,#C6,#09       ;Q)C)..F.
       DB       #81,#0D,#08,#0A,#81,#0B,#18,#0F       ;........
       DB       #08,#A0,#79,#50,#4F,#C0,#89,#3E       ;. yPO@.>
       DB       #55,#69,#51,#6B,#41,#49,#41,#61       ;UiQkAIAa
       DB       #C0,#41,#83,#51,#41,#3E,#79,#20       ;@A.QA>y 
       DB       #66,#70,#79,#E0,#79,#B0,#79,#20       ;fpy`y0y 
       DB       #79,#20,#79,#20,#81,#A8,#7A,#40       ;y y .(z@
       DB       #79,#20,#C2,#00,#79,#20,#7A,#70       ;y B.y zp
       DB       #79,#20,#79,#20,#79,#20,#7A,#70       ;y y y zp
       DB       #79,#20,#7A,#A0,#7B,#00,#7B,#00       ;y z {.{.
       DB       #7A,#D0,#7B,#30,#0B,#30,#81,#3E       ;zP{0.0.>
       DB       #13,#90,#83,#7F,#7F,#57,#03,#90       ;.....W..
       DB       #81,#6B,#79,#80,#82,#00,#FE,#6A       ;.ky...~j
       DB       #40,#C5,#FF,#83,#FE,#FC,#F0,#2B       ;@E..~|p+
       DB       #94,#E9,#00,#81,#FF,#0E,#07,#78       ;.i.....x
       DB       #3A,#E6,#00,#35,#49,#F4,#00,#C0       ;:f.5It.@
       DB       #FF,#85,#7F,#1F,#0F,#07,#03,#78       ;.......x
       DB       #48,#E3,#00,#C8,#FF,#05,#90,#83       ;Hc.H....
       DB       #1F,#3F,#17,#78,#91,#DA,#00,#CE       ;.?.x.Z.N
       DB       #FF,#85,#FE,#78,#30,#0C,#02,#78       ;..~x0..x
       DB       #D6,#D5,#00,#C6,#FF,#07,#50,#82       ;VU.F..P.
       DB       #FC,#F8,#2F,#18,#79,#89,#D5,#00       ;|x/.y.U.
       DB       #84,#FF,#FE,#FE,#FB,#07,#87,#79       ;..~~{..y
       DB       #BA,#FF,#00,#F2,#00,#86,#3F,#7F       ;:..r..?.
       DB       #7D,#7F,#76,#7D,#06,#08,#0E,#04       ;}.v}....
       DB       #82,#54,#3F,#EE,#00,#82,#FF,#DD       ;.T?n...]
       DB       #06,#0C,#8A,#54,#FF,#00,#FE,#41       ;...T..~A
       DB       #09,#41,#81,#21,#FE,#EE,#00,#28       ;.A.!~n.(
       DB       #38,#28,#88,#82,#55,#7F,#EB,#00       ;8(..U.k.
       DB       #28,#C0,#81,#FF,#20,#88,#82,#75       ;(@.. ..u
       DB       #FF,#EB,#00,#68,#C0,#83,#55,#FA       ;.k.h@.Uz
       DB       #0F,#DA,#00,#86,#FF,#FF,#7F,#3F       ;.Z.....?
       DB       #7F,#1F,#3A,#C0,#70,#C0,#81,#AE       ;..:@p@..
       DB       #00,#42,#7B,#25,#4B,#00,#C0,#FE       ;.B{%K.@~
       DB       #81,#FC,#02,#02,#83,#40,#30,#08       ;.|...@0.
       DB       #78,#C0,#89,#00,#57,#BF,#66,#B9       ;x@..W?f9
       DB       #56,#EB,#35,#0E,#7B,#21,#1F,#80       ;Vk5.{!..
       DB       #81,#D0,#63,#F4,#69,#80,#9A,#7D       ;.Pcti..}
       DB       #FF,#03,#02,#83,#43,#A3,#F2,#6B       ;....C#rk
       DB       #F7,#F6,#7B,#7A,#2F,#3A,#1D,#1A       ;wv{z/:..
       DB       #0D,#0F,#05,#06,#03,#02,#03,#02       ;........
       DB       #03,#D3,#00,#29,#B8,#86,#3E,#75       ;.S.)8.>u
       DB       #5B,#75,#6B,#51,#7E,#10,#6F,#C0       ;[ukQ~.o@
       DB       #7E,#40,#7F,#C0,#7F,#C0,#7F,#F0       ;~@.@.@.p
       DB       #7F,#90,#7E,#70,#7F,#F0,#7F,#F0       ;..~p.p.p
       DB       #7F,#90,#7F,#90,#7F,#90,#7F,#90       ;........
       DB       #7F,#90,#7F,#90,#7F,#90,#7F,#90       ;........
       DB       #7F,#90,#7F,#90,#7F,#90,#7F,#90       ;........
       DB       #7F,#C0,#7F,#30,#7F,#90,#7F,#F0       ;.@.0...p
       DB       #7F,#C0,#7F,#C0,#7F,#90,#7F,#F0       ;.@.@...p
       DB       #7F,#F0,#7F,#C0,#7F,#90,#7F,#60       ;.p.@...`
       DB       #7F,#C0,#7F,#90,#7F,#60,#7F,#F0       ;.@...`.p
       DB       #7F,#C0,#7F,#90,#7F,#90,#7F,#F0       ;.@.....p
       DB       #7F,#C0,#7F,#F0,#7F,#F0,#7F,#F0       ;.@.p.p.p
       DB       #7F,#F0,#7F,#F0,#7F,#F0,#7F,#F0       ;.p.p.p.p
       DB       #81,#FE,#78,#30,#40,#30,#82,#3E       ;.~x0@0.>
       DB       #00,#D3,#49,#81,#4F,#C0,#4A,#C3       ;.SI.O@JC
       DB       #42,#D1,#49,#C1,#4A,#C5,#42,#78       ;BQIAJEBx
       DB       #40,#48,#1E,#82,#42,#42,#D1,#4A       ;@H..BBQJ
       DB       #C9,#42,#78,#20,#CB,#42,#78,#3D       ;IBx KBx=
       DB       #58,#20,#CE,#4D,#CC,#47,#78,#20       ;X NMLGx 
       DB       #78,#20,#78,#40,#C0,#46,#20,#48       ;x x@@F H
       DB       #CE,#6E,#78,#20,#78,#20,#78,#40       ;Nnx x x@
       DB       #78,#40,#20,#A8,#CF,#72,#28,#C1       ;x@ (Or(A
       DB       #18,#84,#78,#20,#58,#20,#39,#6A       ;..x X 9j
       DB       #28,#0B,#78,#20,#30,#17,#78,#20       ;(.x 0.x 
       DB       #48,#40,#20,#4E,#59,#41,#78,#20       ;H@ NYAx 
       DB       #78,#20,#12,#2A,#C6,#45,#49,#3E       ;x .*FEI>
       DB       #78,#20,#78,#20,#22,#4A,#C5,#46       ;x x "JEF
       DB       #51,#7E,#48,#E0,#20,#23,#78,#20       ;Q~H` #x 
       DB       #58,#23,#62,#00,#CD,#42,#68,#20       ;X#b.MBh 
       DB       #80,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00       ;..
;
DepackMenu
	halt;DI
	LD	HL,L_8837
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_87A9	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_87E8
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_87C3	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_87DD
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_87DD	LD	A,(HL)
	CALL	L_8810
	POP	HL
	INC	HL
	DJNZ	L_87C3
	POP	HL
	JR	L_87A9
;
L_87E8	AND	#7F
	JR	Z,L_8809
	INC	HL
	BIT	6,A
	JR	NZ,L_87FB
	LD	B,A
L_87F2	LD	A,(HL)
	CALL	L_8810
	INC	HL
	DJNZ	L_87F2
	JR	L_87A9
;
L_87FB	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_8801	CALL	L_8810
	DJNZ	L_8801
	INC	HL
	JR	L_87A9
;
L_8809	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
L_8810	INC	DE
	EXX
	LD	(HL),A
	EX	AF,AF' ;'
	JR	Z,L_882F
	INC	H
	DJNZ	L_8834
	LD	DE,0xF820
	ADD	HL,DE
	DEC	C
	JR	NZ,L_8832
	LD	DE,0xFF01
	ADD	HL,DE
	ADD	A,#08
	JR	NC,L_8830
	LD	DE,#07E0
	ADD	HL,DE
	DEC	A
	JR	L_8830
;
L_882F	INC	HL
L_8830	LD	C,#08
L_8832	LD	B,#08
L_8834	EX	AF,AF' ;'
	EXX
	RET
;
L_8837       DB       #FF,#00,#FB,#00,#89,#FF,#80,#80       ;..{.....
       DB       #95,#8A,#97,#8F,#97,#8F,#08,#04       ;........
       DB       #28,#08,#68,#10,#85,#97,#80,#FF       ;(.h.....
       DB       #00,#7F,#78,#30,#08,#18,#85,#FF       ;..x0....
       DB       #00,#00,#55,#AA,#C6,#FF,#81,#FC       ;..U*F..|
       DB       #C7,#FD,#84,#FC,#FC,#FD,#FE,#30       ;G}.||}~0
       DB       #18,#83,#00,#FF,#00,#00,#29,#10       ;......).
       DB       #70,#50,#30,#81,#00,#60,#40,#00       ;pP0..`@.
       DB       #28,#81,#7F,#C3,#40,#70,#18,#78       ;(..C@p.x
       DB       #40,#78,#40,#78,#68,#78,#80,#78       ;@x@xhx.x
       DB       #80,#78,#68,#70,#A8,#81,#0F,#39       ;.xhp(..9
       DB       #22,#84,#17,#0F,#57,#AF,#48,#C0       ;"...W/H@
       DB       #84,#01,#01,#55,#A9,#30,#F6,#81       ;...U)0v.
       DB       #01,#38,#E8,#50,#18,#D5,#FD,#00       ;.8hP.U}.
       DB       #30,#CD,#40,#81,#C0,#22,#12,#E4       ;0M@.@".d
       DB       #40,#79,#C0,#79,#CC,#79,#DE,#41       ;@y@yLy^A
       DB       #C0,#78,#A8,#DB,#FD,#69,#D8,#EC       ;@x([}iXl
       DB       #40,#71,#F0,#EC,#00,#78,#40,#EB       ;@qpl.x@k
       DB       #00,#78,#80,#EB,#00,#71,#F0,#ED       ;.x.k.qpm
       DB       #00,#79,#C0,#7B,#80,#7B,#90,#7B       ;.y@{.{.{
       DB       #A2,#7B,#80,#7B,#80,#7B,#98,#72       ;"{.{.{.r
       DB       #80,#7B,#80,#7B,#80,#4B,#98,#79       ;.{.{.K.y
       DB       #D0,#7B,#A8,#7B,#E8,#3C,#00,#79       ;P{({h<.y
       DB       #D0,#7B,#68,#7B,#68,#43,#80,#7A       ;P{h{hC.z
       DB       #C0,#7B,#68,#E6,#FD,#7B,#80,#ED       ;@{hf}{.m
       DB       #40,#7D,#40,#7D,#4C,#7D,#5E,#7D       ;@}@}L}^}
       DB       #40,#7D,#40,#79,#C0,#7D,#58,#7D       ;@}@y@}X}
       DB       #40,#7D,#40,#7D,#58,#7D,#80,#7C       ;@}@}X}.|
       DB       #E8,#6C,#E8,#7D,#C0,#7D,#00,#7C       ;hlh}@}.|
       DB       #28,#7D,#40,#70,#58,#D4,#40,#7D       ;(}@pXT@}
       DB       #40,#D1,#FD,#83,#01,#FF,#F9,#C0       ;@Q}...y@
       DB       #21,#D2,#00,#E4,#40,#84,#10,#B0       ;!R.d@..0
       DB       #50,#10,#FF,#00,#FF,#00,#FF,#00       ;P.......
       DB       #F4,#00,#27,#D8,#F6,#00,#7D,#C2       ;t.'Xv.}B
       DB       #EB,#00,#27,#D8,#81,#0D,#C1,#0F       ;k.'X..A.
       DB       #8D,#0E,#0F,#07,#0B,#07,#0B,#05       ;........
       DB       #0A,#05,#0E,#07,#0F,#07,#00,#11       ;........
       DB       #81,#0D,#08,#08,#84,#0B,#05,#0F       ;........
       DB       #0F,#D8,#00,#27,#F0,#85,#55,#AA       ;.X.'p.U*
       DB       #D7,#AF,#5F,#C0,#FF,#C0,#F0,#86       ;W/_@.@p.
       DB       #EA,#F5,#6F,#FF,#7F,#BF,#10,#0B       ;juo..?..
       DB       #88,#E0,#70,#A0,#50,#A0,#D0,#A0       ;.`p P P 
       DB       #50,#D8,#00,#27,#F0,#88,#57,#EF       ;PX.'p.Wo
       DB       #FF,#FE,#FD,#FA,#D5,#AA,#C0,#00       ;.~}zU*@.
       DB       #88,#FE,#FF,#BF,#DF,#EF,#D5,#EA       ;.~.?_oUj
       DB       #55,#E3,#00,#27,#F0,#88,#FA,#BF       ;Uc.'p.z?
       DB       #7F,#FF,#7F,#FF,#7F,#AE,#C0,#00       ;......@.
       DB       #83,#AA,#F5,#FA,#07,#21,#81,#EF       ;.*uz.!.o
       DB       #78,#40,#D1,#00,#2F,#F0,#88,#AA       ;x@Q./p.*
       DB       #57,#EB,#F7,#FB,#FD,#7F,#AF,#07       ;Wkw{}./.
       DB       #FE,#83,#AD,#7E,#FD,#00,#BF,#82       ;~.-~}.?.
       DB       #FA,#D5,#E3,#00,#21,#C0,#83,#D5       ;zUc.!@.U
       DB       #EF,#FB,#0F,#98,#81,#BF,#01,#47       ;o{...?.G
       DB       #89,#5F,#BF,#FB,#F7,#AF,#5F,#BF       ;._?{w/_?
       DB       #5F,#0D,#01,#4C,#83,#06,#0D,#0B       ;_..L....
       DB       #09,#48,#D8,#00,#27,#82,#01,#2C       ;.HX.'..,
       DB       #81,#F0,#01,#2C,#01,#2E,#83,#E0       ;.p.,...`
       DB       #D0,#E0,#C1,#F0,#82,#E0,#D0,#09       ;P`Ap.`P.
       DB       #39,#82,#A0,#70,#00,#0D,#81,#B0       ;9. p...0
       DB       #79,#40,#84,#00,#00,#1C,#3C,#C0       ;y@....<@
       DB       #1C,#81,#7E,#7A,#00,#ED,#00,#27       ;..~z.m.'
       DB       #C2,#82,#0A,#0F,#01,#F2,#01,#FA       ;B....r.z
       DB       #83,#0B,#05,#0B,#19,#FC,#81,#0F       ;.....|..
       DB       #02,#04,#00,#0C,#82,#0D,#0E,#02       ;........
       DB       #19,#81,#0A,#D0,#00,#81,#3E,#C1       ;...P..>A
       DB       #70,#81,#3E,#32,#80,#82,#BA,#7D       ;p.>2..:}
       DB       #00,#FD,#83,#7F,#FF,#FD,#08,#C8       ;.}...}.H
       DB       #00,#C2,#08,#BB,#00,#D2,#81,#FD       ;.B.;.R.}
       DB       #07,#EA,#83,#5F,#AF,#57,#09,#D6       ;.j._/W.V
       DB       #CD,#00,#81,#7F,#C2,#1C,#32,#C0       ;M...B.2@
       DB       #88,#AA,#5F,#AF,#DF,#EF,#FF,#BF       ;.*_/_o.?
       DB       #5D,#CB,#00,#88,#55,#AB,#D7,#BF       ;]K..U+W?
       DB       #7F,#FE,#FD,#EA,#D0,#00,#86,#3C       ;.~}jP..<
       DB       #72,#72,#7E,#72,#72,#31,#C0,#01       ;rr~rr1@.
       DB       #F3,#84,#FD,#FB,#D7,#AA,#0A,#35       ;s.}{W*.5
       DB       #82,#3A,#3D,#C0,#3F,#83,#3E,#35       ;.:=@?.>5
       DB       #2A,#C0,#00,#81,#7F,#00,#16,#84       ;*@......
       DB       #FE,#FF,#FE,#F5,#D0,#00,#86,#7C       ;~.~uP..|
       DB       #72,#72,#7C,#70,#70,#33,#80,#82       ;rr|pp3..
       DB       #B5,#7E,#02,#B2,#83,#FF,#FD,#5A       ;5~.2..}Z
       DB       #07,#3E,#86,#BD,#FF,#DF,#BF,#7F       ;.>.=._?.
       DB       #BF,#12,#4B,#87,#55,#EA,#F5,#FE       ;?.K.Uju~
       DB       #FF,#5F,#AB,#7A,#8B,#70,#C0,#00       ;._+z.p@.
       DB       #2A,#83,#EF,#DF,#FF,#10,#AA,#87       ;*.o_..*.
       DB       #55,#AB,#D5,#FB,#FD,#BE,#7F,#12       ;U+U{}>..
       DB       #0B,#81,#FF,#06,#44,#81,#FB,#78       ;....D.{x
       DB       #C0,#7A,#80,#81,#50,#09,#F4,#83       ;@z..P.t.
       DB       #B0,#70,#B0,#C0,#00,#81,#70,#C3       ;0p0@..pC
       DB       #F0,#39,#46,#81,#F0,#08,#16,#6F       ;p9F.p..o
       DB       #BF,#84,#72,#72,#76,#7A,#01,#00       ;?.rrvz..
       DB       #F6,#00,#11,#C0,#39,#00,#82,#0F       ;v..@9...
       DB       #07,#01,#FC,#03,#FE,#03,#F8,#82       ;..|.~.x.
       DB       #0E,#0D,#0C,#06,#04,#11,#32,#11       ;......2.
       DB       #7A,#00,#39,#40,#2B,#80,#02,#00       ;z.9@+...
       DB       #84,#FF,#FF,#D7,#AA,#02,#C3,#81       ;...W*.C.
       DB       #EF,#03,#7D,#84,#F7,#FA,#FD,#FA       ;o.}.wz}z
       DB       #02,#B9,#86,#7A,#FD,#FE,#FD,#FB       ;.9.z}~}{
       DB       #F7,#13,#56,#78,#C0,#09,#82,#33       ;w.Vx@..3
       DB       #80,#81,#AB,#0A,#00,#83,#F7,#FF       ;..+...w.
       DB       #BD,#11,#75,#81,#F7,#00,#43,#82       ;=.u.w.C.
       DB       #7F,#AD,#08,#16,#81,#57,#03,#D7       ;.-...W.W
       DB       #7B,#8B,#7D,#40,#07,#89,#84,#FB       ;{.}@...{
       DB       #F7,#EF,#DF,#11,#AA,#81,#5D,#12       ;wo_.*.].
       DB       #0B,#11,#B5,#85,#EA,#FD,#FF,#F7       ;..5.j}.w
       DB       #EF,#02,#81,#D8,#00,#39,#C0,#85       ;o..X.9@.
       DB       #FE,#FF,#FB,#F7,#6A,#09,#8B,#81       ;~.{wj...
       DB       #B0,#0B,#8D,#82,#F0,#F0,#38,#96       ;0...pp8.
       DB       #81,#FF,#D8,#00,#27,#98,#86,#5F       ;..X.'.._
       DB       #FF,#7B,#FD,#7E,#BD,#6A,#6A,#02       ;.{}~=jj.
       DB       #3E,#83,#DF,#EF,#F5,#7C,#CB,#7D       ;>._ou|K}
       DB       #C0,#08,#75,#81,#F0,#05,#2E,#5F       ;@.u.p.._
       DB       #4C,#82,#70,#F0,#02,#0D,#82,#E0       ;L.pp...`
       DB       #F0,#7D,#40,#7E,#00,#F5,#00,#7E       ;p}@~.u.~
       DB       #40,#EA,#00,#2D,#40,#FF,#00,#FF       ;@j.-@...
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#E6,#00,#85       ;.....f..
       DB       #7C,#0E,#0E,#3C,#70,#07,#D0,#38       ;|..<p.P8
       DB       #10,#84,#3C,#0E,#0E,#7C,#3F,#F9       ;..<..|?y
       DB       #C0,#4E,#83,#3E,#0E,#0E,#C7,#00       ;@N.>..G.
       DB       #82,#7C,#60,#00,#32,#40,#20,#FD       ;.|`.2@ }
       DB       #00,#81,#7C,#1D,#90,#58,#70,#81       ;..|..Xp.
       DB       #3C,#7E,#70,#C5,#00,#27,#80,#C6       ;<~pE.'.F
       DB       #00,#68,#40,#81,#7E,#C2,#4E,#4E       ;.h@.~BNN
       DB       #B0,#07,#AF,#78,#30,#C6,#00,#07       ;0./x0F..
       DB       #D0,#82,#72,#72,#40,#70,#2F,#A0       ;P.rr@p/ 
       DB       #56,#B0,#81,#3E,#C7,#00,#2F,#80       ;V0.>G./.
       DB       #2F,#DB,#81,#1E,#C1,#2E,#82,#7E       ;/[..A..~
       DB       #42,#C6,#00,#68,#A0,#68,#30,#68       ;BF.h h0h
       DB       #70,#7E,#E0,#59,#10,#68,#90,#68       ;p~`Y.h.h
       DB       #A0,#16,#D0,#47,#90,#81,#3E,#61       ; .PG..>a
       DB       #00,#79,#50,#79,#00,#49,#00,#82       ;.yPy.I..
       DB       #3E,#70,#07,#5F,#40,#F0,#68,#60       ;>p._@ph`
       DB       #6F,#FA,#69,#00,#69,#70,#11,#8F       ;ozi.ip..
       DB       #82,#3E,#02,#D6,#00,#69,#D0,#69       ;.>.V.iPi
       DB       #F0,#6A,#00,#DD,#00,#68,#C0,#01       ;pj.].h@.
       DB       #10,#01,#13,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FC,#00,#82       ;.....|..
       DB       #42,#42,#C3,#47,#00,#07,#C2,#42       ;BBCG..BB
       DB       #30,#0E,#08,#14,#82,#45,#45,#48       ;0....EEH
       DB       #12,#78,#20,#20,#20,#20,#39,#20       ;.x    9 
       DB       #40,#10,#12,#38,#51,#78,#60,#30       ;@..8Qx`0
       DB       #60,#60,#72,#78,#20,#C6,#42,#48       ;``rx FBH
       DB       #A0,#30,#0E,#78,#B2,#38,#19,#78       ; 0.x28.x
       DB       #60,#78,#20,#40,#60,#D7,#42,#FF       ;`x @`WB.
       DB       #46,#FF,#46,#D9,#46,#E7,#47,#C9       ;F.FYFgGI
       DB       #44,#F1,#47,#C9,#45,#FF,#47,#EF       ;DqGIE.Go
       DB       #47,#78,#F6,#EB,#47,#49,#ED,#39       ;GxvkGIm9
       DB       #36,#80       ;6.
;
DepackHelp1
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_8D15	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_8D54
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_8D2F	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_8D49
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_8D49	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_8D2F
	POP	HL
	JR	L_8D15
;
L_8D54	AND	#7F
	JR	Z,L_8D75
	INC	HL
	BIT	6,A
	JR	NZ,L_8D67
	LD	B,A
L_8D5E	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_8D5E
	JR	L_8D15
;
L_8D67	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_8D6D	CALL	L_74A6
	DJNZ	L_8D6D
	INC	HL
	JR	L_8D15
;
L_8D75	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#C6       ;.....YIF
       DB       #00,#83,#5D,#5D,#3E,#C0,#5D,#83       ;..]]>@].
       DB       #00,#00,#3C,#C1,#72,#8E,#3C,#00       ;..<Ar.<.
       DB       #00,#72,#72,#76,#7A,#72,#72,#00       ;.rrvzrr.
       DB       #00,#71,#7B,#75,#C0,#71,#83,#00       ;.q{u@q..
       DB       #00,#3E,#C1,#70,#81,#3E,#28,#08       ;.>Ap.>(.
       DB       #38,#20,#28,#41,#28,#30,#86,#7C       ;8 (A(0.|
       DB       #70,#7C,#72,#72,#7C,#38,#18,#83       ;p|rr|8..
       DB       #3E,#70,#7C,#50,#30,#81,#7E,#C2       ;>p|P0.~B
       DB       #4E,#CF,#00,#81,#3E,#20,#18,#68       ;NO..> .h
       DB       #48,#00,#2F,#83,#3E,#0E,#0E,#38       ;H./.>..8
       DB       #20,#08,#5E,#82,#70,#70,#38,#68       ; .^.pp8h
       DB       #81,#1E,#C1,#2E,#82,#7E,#42,#30       ;..A..~B0
       DB       #B8,#28,#10,#00,#85,#10,#88,#81       ;8(......
       DB       #7F,#C2,#1C,#83,#00,#00,#70,#20       ;.B....p 
       DB       #98,#00,#E0,#81,#7E,#08,#D8,#28       ;..`.~.X(
       DB       #E8,#28,#10,#00,#FA,#00,#F6,#08       ;h(..z.v.
       DB       #F8,#00,#1F,#00,#F8,#28,#90,#28       ;x...x(.(
       DB       #30,#28,#18,#81,#7C,#20,#58,#30       ;0(..| X0
       DB       #88,#28,#10,#38,#60,#60,#58,#84       ;.(.8``X.
       DB       #00,#00,#18,#18,#09,#50,#19,#18       ;.....P..
       DB       #29,#10,#39,#68,#18,#70,#68,#20       ;).9h.ph 
       DB       #69,#22,#29,#88,#28,#F0,#28,#D8       ;i").(p(X
       DB       #30,#58,#61,#58,#11,#38,#18,#E0       ;0XaX.8.`
       DB       #11,#D0,#69,#68,#29,#10,#29,#E0       ;.Pih).)`
       DB       #69,#40,#39,#D8,#19,#10,#39,#58       ;i@9X..9X
       DB       #1A,#18,#2A,#10,#69,#CA,#29,#A0       ;..*.iJ) 
       DB       #29,#48,#68,#18,#29,#40,#01,#F0       ;)Hh.)@.p
       DB       #01,#F3,#79,#C0,#29,#A0,#3A,#38       ;.sy@) :8
       DB       #0A,#92,#79,#B8,#2A,#B9,#29,#D0       ;..y8*9)P
       DB       #2A,#28,#11,#F8,#28,#A0,#02,#28       ;*(.x( .(
       DB       #3A,#D0,#40,#18,#42,#C8,#30,#90       ;:P@.BH0.
       DB       #61,#98,#2B,#08,#2A,#40,#68,#10       ;a.+.*@h.
       DB       #79,#C0,#29,#C8,#58,#F8,#3B,#00       ;y@)HXx;.
       DB       #1A,#58,#2A,#88,#40,#C0,#13,#70       ;.X*.@@.p
       DB       #42,#A0,#52,#C8,#42,#88,#31,#C8       ;B RHB.1H
       DB       #89,#18,#18,#30,#00,#7C,#0E,#3C       ;...0.|.<
       DB       #0E,#0E,#43,#68,#39,#80,#5A,#E8       ;..Ch9.Zh
       DB       #6A,#40,#6B,#70,#2A,#D0,#2B,#E8       ;j@kp*P+h
       DB       #33,#C8,#32,#B0,#39,#E8,#08,#78       ;3H209h.x
       DB       #69,#20,#69,#88,#3B,#80,#1B,#48       ;i i.;..H
       DB       #2B,#80,#32,#20,#62,#78,#68,#E8       ;+.2 bxhh
       DB       #43,#80,#12,#20,#69,#E0,#4B,#20       ;C.. i`K 
       DB       #0B,#58,#6A,#30,#2C,#C0,#2A,#60       ;.Xj0,@*`
       DB       #2C,#00,#2C,#08,#2C,#40,#7C,#78       ;,.,.,@|x
       DB       #23,#F8,#63,#80,#69,#98,#6C,#D0       ;#xc.i.lP
       DB       #2C,#E0,#69,#D8,#69,#A0,#2D,#18       ;,`iXi -.
       DB       #2A,#98,#3D,#38,#1A,#B0,#2A,#B8       ;*.=8.0*8
       DB       #2D,#20,#2C,#A8,#2D,#50,#2C,#D0       ;- ,(-P,P
       DB       #7C,#C0,#5A,#B0,#6C,#98,#6C,#00       ;|@Z0l.l.
       DB       #2D,#10,#25,#38,#81,#08,#68,#C8       ;-.%8..hH
       DB       #68,#D8,#35,#78,#22,#70,#2D,#48       ;hX5x"p-H
       DB       #6B,#E0,#6A,#80,#7D,#78,#5A,#90       ;k`j.}xZ.
       DB       #3B,#E8,#5E,#50,#2E,#78,#2D,#88       ;;h^P.x-.
       DB       #C2,#75,#06,#78,#10,#08,#82,#3F       ;Bu.x...?
       DB       #01,#36,#88,#2E,#B0,#6A,#60,#46       ;.6..0j`F
       DB       #10,#25,#B8,#58,#58,#2E,#68,#2E       ;.%8XX.h.
       DB       #38,#6E,#50,#40,#F8,#14,#A0,#2F       ;8nP@x. /
       DB       #00,#28,#80,#3E,#10,#5E,#50,#6B       ;.(.>.^Pk
       DB       #E8,#6E,#E2,#69,#D0,#6D,#60,#2B       ;hnbiPm`+
       DB       #D0,#7F,#58,#1F,#88,#6D,#F0,#6C       ;P.X..mpl
       DB       #B8,#2E,#C0,#7E,#40,#5A,#C8,#2D       ;8.@~@ZH-
       DB       #50,#3F,#A0,#1F,#D8,#42,#78,#85       ;P? .XBx.
       DB       #72,#72,#3C,#00,#00,#39,#20,#1F       ;rr<..9 .
       DB       #D0,#83,#36,#36,#6C,#51,#60,#2C       ;P.66lQ`,
       DB       #80,#32,#A8,#81,#72,#1F,#98,#2F       ;.2(.r../
       DB       #B0,#6F,#68,#6F,#38,#2F,#88,#6E       ;0oho8/.n
       DB       #80,#6A,#78,#69,#08,#2E,#D8,#2B       ;.jxi..X+
       DB       #28,#3F,#58,#1D,#F0,#6E,#78,#2B       ;(?X.pnx+
       DB       #50,#2A,#30,#60,#28,#33,#00,#2F       ;P*0`(3./
       DB       #30,#6D,#88,#81,#3C,#C1,#72,#07       ;0m..<Ar.
       DB       #D0,#2F,#50,#6D,#B8,#6F,#58,#6F       ;P/Pm8oXo
       DB       #BA,#6D,#40,#6D,#88,#3E,#A0,#1F       ;:m@m.> .
       DB       #58,#35,#F8,#27,#60,#78,#30,#61       ;X5x'`x0a
       DB       #50,#27,#C8,#6B,#F0,#6C,#00,#27       ;P'Hkpl.'
       DB       #20,#81,#04,#7B,#F0,#5E,#30,#2D       ; ..{p^0-
       DB       #A0,#6F,#00,#4D,#C8,#0E,#80,#81       ; o.MH...
       DB       #3E,#C1,#70,#83,#3E,#00,#00,#35       ;>Ap.>..5
       DB       #98,#36,#50,#86,#72,#7C,#70,#70       ;.6P.r|pp
       DB       #00,#00,#2F,#C0,#41,#F0,#57,#B8       ;../@ApW8
       DB       #6C,#48,#50,#50,#82,#3C,#00,#74       ;lHPP.<.t
       DB       #98,#6B,#10,#C5,#00,#32,#00,#83       ;.k.E.2..
       DB       #4E,#4E,#3E,#0F,#28,#81,#76,#C1       ;NN>.(.vA
       DB       #79,#81,#76,#C7,#00,#2F,#40,#69       ;y.vG./@i
       DB       #C0,#81,#3E,#1F,#58,#35,#00,#6F       ;@.>.X5.o
       DB       #4A,#42,#98,#57,#48,#2E,#98,#6E       ;JB.WH..n
       DB       #28,#2D,#B8,#04,#96,#81,#3E,#0E       ;(-8...>.
       DB       #F0,#6E,#48,#6F,#08,#2F,#58,#44       ;pnHo./XD
       DB       #B0,#82,#72,#72,#46,#60,#2E,#F0       ;0.rrF`.p
       DB       #6E,#98,#2E,#20,#3B,#C0,#5E,#B0       ;n.. ;@^0
       DB       #29,#00,#2F,#78,#79,#D8,#5F,#C0       ;)./xyX_@
       DB       #47,#70,#33,#70,#19,#E0,#81,#7C       ;Gp3p.`.|
       DB       #57,#08,#6D,#10,#6E,#10,#7C,#78       ;W.m.n.|x
       DB       #1F,#A0,#6E,#28,#46,#B8,#59,#58       ;. n(F8YX
       DB       #36,#08,#1F,#10,#68,#E0,#53,#18       ;6...h`S.
       DB       #16,#E0,#1F,#C8,#2D,#F0,#2C,#18       ;.`.H-p,.
       DB       #81,#3C,#C1,#72,#84,#3C,#00,#00       ;.<Ar.<..
       DB       #3E,#31,#88,#1F,#70,#6B,#C8,#2F       ;>1..pkH/
       DB       #C0,#2F,#30,#6F,#20,#2F,#E8,#37       ;@/0o /h7
       DB       #58,#67,#E0,#2F,#18,#6E,#68,#34       ;Xg`/.nh4
       DB       #C8,#26,#40,#C5,#00,#81,#7C,#27       ;H&@E..|'
       DB       #98,#38,#60,#78,#F0,#48,#28,#6E       ;.8`xpH(n
       DB       #00,#7D,#20,#1E,#A0,#81,#3C,#C1       ;.} . .<A
       DB       #72,#83,#3C,#00,#00,#74,#00,#27       ;r.<..t.'
       DB       #B0,#6A,#28,#7E,#80,#53,#80,#35       ;0j(~.S.5
       DB       #10,#6F,#A0,#6A,#70,#2F,#20,#2D       ;.o jp/ -
       DB       #F0,#7F,#88,#1F,#88,#29,#D0,#2F       ;p....)P/
       DB       #E8,#2E,#48,#2F,#78,#69,#88,#2E       ;h.H/xi..
       DB       #88,#41,#D0,#57,#60,#3A,#58,#1A       ;.APW`:X.
       DB       #28,#38,#60,#59,#B0,#6A,#A8,#79       ;(8`Y0j(y
       DB       #58,#5F,#68,#2F,#60,#2F,#58,#6E       ;X_h/`/Xn
       DB       #C8,#6F,#10,#6D,#C8,#7D,#58,#25       ;Ho.mH}X%
       DB       #68,#3C,#80,#07,#1A,#82,#02,#00       ;h<......
       DB       #6E,#A0,#7E,#40,#1F,#C8,#82,#00       ;n ~@.H..
       DB       #00,#1F,#D0,#69,#00,#7F,#E0,#DB       ;..Pi..`[
       DB       #00,#0B,#84,#0B,#88,#2E,#80,#38       ;.......8
       DB       #60,#C3,#00,#81,#3E,#C1,#70,#83       ;`C..>Ap.
       DB       #3E,#00,#00,#2F,#E0,#6C,#70,#69       ;>../`lpi
       DB       #68,#6E,#A8,#2F,#D8,#2F,#78,#7F       ;hn(/X/x.
       DB       #90,#5B,#68,#2F,#10,#81,#3C,#C1       ;.[h/..<A
       DB       #72,#47,#F0,#83,#3C,#72,#72,#0E       ;rGp.<rr.
       DB       #80,#4A,#80,#17,#80,#C2,#75,#46       ;.J...BuF
       DB       #A8,#2F,#F8,#2E,#F8,#6D,#58,#6F       ;(/x.xmXo
       DB       #82,#2E,#D8,#28,#48,#3F,#40,#5E       ;..X(H?@^
       DB       #98,#37,#50,#2A,#30,#24,#E0,#6C       ;.7P*0$`l
       DB       #10,#2F,#E8,#2F,#38,#2F,#D0,#6F       ;./h/8/Po
       DB       #48,#6E,#38,#C5,#00,#2E,#F0,#6F       ;Hn8E..po
       DB       #D8,#6F,#F0,#33,#38,#2F,#58,#25       ;Xop38/X%
       DB       #70,#7F,#00,#5C,#78,#81,#3C,#C1       ;p..\x.<A
       DB       #72,#83,#3C,#00,#00,#6D,#E8,#2F       ;r.<..mh/
       DB       #E0,#2F,#D0,#2E,#78,#57,#48,#83       ;`/P.xWH.
       DB       #72,#00,#00,#70,#78,#62,#F0,#2F       ;r..pxbp/
       DB       #F8,#37,#E8,#26,#F0,#4F,#E0,#0E       ;x7h&pO`.
       DB       #40,#6D,#98,#40,#D0,#2C,#B8,#4B       ;@m.@P,8K
       DB       #D8,#77,#88,#6A,#00,#4F,#88,#0E       ;Xw.j.O..
       DB       #A0,#68,#50,#7B,#C8,#2A,#98,#5E       ; hP{H*.^
       DB       #50,#C5,#00,#48,#B0,#37,#90,#14       ;PE.H07..
       DB       #90,#79,#C8,#84,#72,#72,#00,#00       ;.yH.rr..
       DB       #2F,#C0,#2F,#C8,#55,#38,#46,#60       ;/@/HU8F`
       DB       #79,#E8,#27,#30,#48,#90,#4D,#A8       ;yh'0H.M(
       DB       #26,#C8,#6E,#D0,#3B,#50,#5E,#58       ;&HnP;P^X
       DB       #2F,#FA,#2F,#88,#7B,#48,#2F,#D8       ;/z/.{H/X
       DB       #76,#B0,#17,#C0,#6D,#88,#72,#88       ;v0.@m.r.
       DB       #26,#D8,#88,#3E,#70,#7C,#70,#70       ;&X.>p|pp
       DB       #3E,#00,#00,#7D,#28,#3D,#E8,#4D       ;>..}(=hM
       DB       #88,#88,#3E,#70,#7C,#70,#70,#3E       ;..>p|pp>
       DB       #00,#00,#07,#77,#C0,#5D,#CF,#00       ;...w@]O.
       DB       #2E,#90,#83,#3C,#72,#72,#57,#F8       ;...<rrWx
       DB       #3E,#D8,#C0,#70,#83,#3E,#00,#00       ;>X@p.>..
       DB       #36,#A8,#81,#0E,#06,#57,#43,#90       ;6(...WC.
       DB       #3F,#68,#26,#B0,#27,#E0,#6F,#B8       ;?h&0'`o8
       DB       #2E,#D0,#2F,#C8,#2F,#A0,#2F,#20       ;.P/H/ / 
       DB       #6D,#48,#2E,#70,#81,#70,#67,#E0       ;mH.p.pg`
       DB       #57,#00,#14,#B8,#81,#7C,#17,#B0       ;W..8.|.0
       DB       #2C,#90,#83,#3E,#4E,#4E,#17,#E0       ;,..>NN.`
       DB       #6F,#B0,#2E,#C0,#29,#08,#6B,#78       ;o0.@).kx
       DB       #78,#68,#1F,#D8,#3E,#80,#86,#72       ;xh.X>..r
       DB       #7C,#70,#70,#00,#00,#6D,#68,#6E       ;|pp..mhn
       DB       #38,#2F,#A8,#6F,#B0,#81,#3C,#C1       ;8/(o0.<A
       DB       #72,#81,#3C,#C3,#00,#4B,#28,#31       ;r.<C.K(1
       DB       #08,#87,#70,#7C,#72,#72,#7C,#00       ;..p|rr|.
       DB       #00,#33,#C8,#5C,#58,#87,#08,#72       ;.3H\X..r
       DB       #72,#76,#7A,#72,#72,#C7,#00,#37       ;rvzrrG.7
       DB       #80,#3B,#B8,#17,#60,#2F,#F8,#3D       ;.;8.`/x=
       DB       #F8,#59,#78,#2F,#F8,#7A,#60,#5A       ;xYx/xz`Z
       DB       #60,#3E,#D8,#1E,#88,#6E,#00,#2F       ;`>X..n./
       DB       #A8,#2F,#D0,#29,#A8,#2F,#D8,#2E       ;(/P)(/X.
       DB       #C0,#6E,#08,#6A,#A8,#79,#C0,#22       ;@n.j(y@"
       DB       #E8,#64,#E8,#88,#7C,#72,#7C,#72       ;hdh.|r|r
       DB       #72,#7C,#00,#00,#68,#80,#38,#F0       ;r|..h.8p
       DB       #71,#70,#67,#A0,#5D,#20,#6C,#98       ;qpg ] l.
       DB       #4D,#F8,#2F,#9C,#1B,#48,#7F,#78       ;Mx/..H.x
       DB       #4F,#58,#7E,#50,#82,#00,#00,#2F       ;OX~P.../
       DB       #D8,#C3,#00,#6F,#D8,#57,#58,#C6       ;XC.oXWXF
       DB       #00,#4E,#40,#03,#C0,#FF,#47,#FF       ;.N@.@.G.
       DB       #47,#FF,#47,#EB,#47,#FF,#46,#FF       ;G.GkG.F.
       DB       #46,#E5,#46,#F8,#42,#FF,#46,#78       ;FeFxB.Fx
       DB       #80,#FF,#42,#FF,#42,#FB,#42,#61       ;..B.B{Ba
       DB       #FD,#80       ;}.
;
DepackHelp2
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_9362	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_93A1
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_937C	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_9396
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_9396	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_937C
	POP	HL
	JR	L_9362
;
L_93A1	AND	#7F
	JR	Z,L_93C2
	INC	HL
	BIT	6,A
	JR	NZ,L_93B4
	LD	B,A
L_93AB	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_93AB
	JR	L_9362
;
L_93B4	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_93BA	CALL	L_74A6
	DJNZ	L_93BA
	INC	HL
	JR	L_9362
;
L_93C2	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#82       ;.....YI.
       DB       #00,#3C,#C1,#72,#84,#3C,#00,#00       ;.<Ar.<..
       DB       #3E,#C1,#70,#8B,#3E,#00,#FF,#80       ;>Ap.>...
       DB       #80,#8A,#95,#8F,#97,#8F,#97,#08       ;........
       DB       #04,#82,#80,#FF,#C7,#00,#81,#7E       ;....G..~
       DB       #C2,#4E,#86,#00,#AA,#7F,#FF,#7F       ;BN..*...
       DB       #FF,#08,#04,#18,#08,#30,#18,#82       ;.....0..
       DB       #00,#7F,#C2,#1C,#86,#00,#FE,#02       ;..B...~.
       DB       #02,#AA,#52,#C5,#FA,#82,#02,#FE       ;.*REz..~
       DB       #38,#40,#88,#7C,#72,#72,#7C,#70       ;8@.|rr|p
       DB       #70,#00,#AA,#CB,#FE,#88,#00,#00       ;p.*K~...
       DB       #72,#72,#76,#7A,#72,#72,#08,#80       ;rrvzrr..
       DB       #00,#1F,#81,#3E,#D7,#00,#28,#A8       ;...>W.((
       DB       #68,#22,#20,#B8,#00,#48,#81,#7E       ;h" 8.H.~
       DB       #00,#CA,#38,#90,#28,#10,#68,#28       ;.J8.(.h(
       DB       #81,#1E,#C1,#2E,#85,#7E,#42,#00       ;..A..~B.
       DB       #7C,#70,#08,#92,#10,#58,#00,#39       ;|p...X.9
       DB       #28,#08,#38,#88,#68,#90,#20,#E0       ;(.8.h. `
       DB       #28,#C8,#30,#B0,#68,#68,#68,#20       ;(H00hhh 
       DB       #40,#C0,#50,#68,#85,#7C,#0E,#3C       ;@@Ph.|.<
       DB       #0E,#0E,#00,#80,#29,#00,#38,#D0       ;....).8P
       DB       #79,#08,#10,#E8,#82,#4E,#4E,#00       ;y..h.NN.
       DB       #03,#09,#30,#01,#4A,#78,#30,#31       ;..0.Jx01
       DB       #A9,#28,#E0,#69,#00,#69,#48,#29       ;)(`i.iH)
       DB       #B8,#69,#72,#81,#7C,#08,#60,#01       ;8ir.|.`.
       DB       #18,#69,#90,#69,#58,#29,#08,#68       ;.i.iX).h
       DB       #48,#29,#D0,#28,#48,#40,#C0,#50       ;H)P(H@@P
       DB       #70,#2A,#78,#29,#50,#2A,#6A,#83       ;p*x)P*j.
       DB       #5D,#5D,#3E,#C0,#5D,#79,#F0,#2A       ;]]>@]yp*
       DB       #28,#2A,#70,#29,#C0,#6A,#38,#2A       ;(*p)@j8*
       DB       #48,#29,#60,#69,#C0,#31,#E0,#22       ;H)`i@1`"
       DB       #B8,#2A,#10,#38,#C0,#1A,#48,#83       ;8*.8@.H.
       DB       #71,#7B,#75,#C0,#71,#48,#D8,#19       ;q{u@qHX.
       DB       #78,#6A,#00,#78,#28,#1A,#D0,#6A       ;xj.x(.Pj
       DB       #B0,#6A,#60,#28,#60,#78,#C0,#1B       ;0j`(`x@.
       DB       #08,#29,#08,#6B,#12,#68,#B0,#2A       ;.).k.h0*
       DB       #98,#6B,#3A,#7A,#00,#59,#E0,#7B       ;.k:z.Y`{
       DB       #58,#5A,#40,#7B,#70,#59,#E0,#78       ;XZ@{pY`x
       DB       #50,#5B,#00,#D5,#00,#14,#68,#78       ;P[.U..hx
       DB       #20,#73,#28,#D5,#00,#68,#20,#6B       ; s(U.h k
       DB       #40,#6B,#20,#7C,#30,#6A,#30,#58       ;@k |0j0X
       DB       #90,#7C,#68,#5C,#94,#69,#70,#6A       ;.|h\.ipj
       DB       #C0,#7B,#78,#7C,#B0,#4C,#E8,#13       ;@{x|0Lh.
       DB       #D0,#59,#90,#79,#00,#7C,#08,#35       ;PY.y.|.5
       DB       #99,#82,#18,#18,#08,#04,#FF,#00       ;........
       DB       #78,#A0,#D3,#00,#7C,#38,#6A,#78       ;x S.|8jx
       DB       #79,#80,#7D,#C8,#D7,#00,#6C,#38       ;y.}HW.l8
       DB       #ED,#00,#7E,#28,#7B,#18,#7D,#18       ;m.~({.}.
       DB       #46,#A8,#64,#38,#7E,#70,#7E,#A8       ;F(d8~p~(
       DB       #4E,#B6,#81,#70,#26,#58,#D4,#00       ;N6.p&XT.
       DB       #81,#08,#6D,#F0,#FF,#00,#FF,#00       ;..mp....
       DB       #47,#48,#8F,#FF,#80,#95,#AA,#95       ;GH....*.
       DB       #A8,#90,#A8,#90,#A0,#90,#A0,#80       ;(.(. . .
       DB       #80,#FF,#C7,#00,#27,#38,#8F,#FF       ;..G.'8..
       DB       #86,#BC,#B8,#BE,#EE,#CE,#80,#CE       ;.<8>nN.N
       DB       #EE,#BE,#B8,#BC,#86,#FF,#C7,#00       ;n>8<..G.
       DB       #81,#7F,#C2,#1C,#85,#00,#FE,#02       ;..B...~.
       DB       #52,#A2,#C7,#02,#81,#FE,#C7,#00       ;R"G..~G.
       DB       #82,#7C,#72,#17,#70,#8F,#FE,#C2       ;.|r.p.~B
       DB       #7A,#3A,#FA,#EE,#E6,#02,#E6,#EE       ;z:znf.fn
       DB       #FA,#3A,#7A,#C2,#FE,#C7,#00,#86       ;z:zB~G..
       DB       #3E,#70,#7C,#70,#70,#3E,#D7,#00       ;>p|pp>W.
       DB       #79,#38,#CB,#00,#82,#72,#72,#1F       ;y8K..rr.
       DB       #18,#81,#7E,#C2,#4E,#82,#00,#00       ;..~BN...
       DB       #6E,#E0,#81,#3E,#C2,#70,#81,#00       ;n`.>Bp..
       DB       #10,#C0,#C3,#BE,#58,#C0,#2E,#A0       ;.@C>X@. 
       DB       #2F,#20,#81,#3E,#7E,#B0,#0F,#C0       ;/ .>~0.@
       DB       #10,#C0,#C3,#FA,#60,#C0,#27,#A0       ;.@Cz`@' 
       DB       #2B,#E0,#6F,#D8,#81,#76,#C1,#79       ;+`oX.vAy
       DB       #81,#76,#D7,#00,#2F,#B0,#81,#3E       ;.vW./0.>
       DB       #27,#98,#6D,#D8,#C2,#75,#84,#3F       ;'.mXBu.?
       DB       #01,#FF,#80,#C1,#BF,#83,#FF,#80       ;...A?...
       DB       #FF,#08,#07,#49,#A0,#30,#40,#27       ;...I 0@'
       DB       #B8,#82,#72,#72,#5D,#08,#28,#C0       ;8.rr].(@
       DB       #81,#02,#00,#BE,#19,#80,#82,#FA       ;...>...z
       DB       #FA,#49,#A0,#6D,#78,#6D,#88,#6C       ;zI mxm.l
       DB       #78,#7C,#98,#1C,#98,#7C,#20,#C3       ;x|...| C
       DB       #00,#81,#3E,#24,#F8,#2E,#80,#07       ;..>$x...
       DB       #C7,#83,#3E,#0E,#3C,#CF,#00,#2F       ;G.>.<O./
       DB       #60,#6E,#68,#2C,#F8,#2F,#58,#6D       ;`nh,x/Xm
       DB       #E8,#2C,#98,#31,#C0,#7C,#C8,#53       ;h,.1@|HS
       DB       #E0,#78,#E0,#1C,#D8,#82,#72,#72       ;`x`.X.rr
       DB       #0F,#BA,#82,#00,#00,#10,#A0,#81       ;.:.... .
       DB       #0E,#C7,#00,#2C,#F8,#2F,#F0,#6C       ;.G.,x/pl
       DB       #28,#6F,#F8,#77,#D8,#62,#60,#6E       ;(oxwXb`n
       DB       #E8,#2F,#C8,#2F,#F8,#78,#60,#1F       ;h/H/xx`.
       DB       #78,#28,#20,#6F,#E0,#2E,#F8,#47       ;x( o`.xG
       DB       #C0,#78,#60,#06,#B8,#2E,#A0,#6E       ;@x`.8. n
       DB       #A8,#2F,#78,#2F,#20,#6F,#28,#2F       ;(/x/ o(/
       DB       #58,#2F,#20,#79,#C0,#C3,#00,#2F       ;X/ y@C./
       DB       #00,#6F,#28,#6F,#D8,#7B,#10,#C3       ;.o(oX{.C
       DB       #00,#7D,#20,#CB,#00,#7E,#80,#7F       ;.} K.~..
       DB       #20,#7E,#A0,#C7,#00,#88,#3E,#70       ; ~ G..>p
       DB       #7C,#70,#70,#3E,#00,#00,#7E,#E8       ;|pp>..~h
       DB       #E3,#00,#2F,#F0,#6B,#A0,#C5,#00       ;c./pk E.
       DB       #29,#80,#D5,#00,#82,#3E,#70,#1E       ;).U..>p.
       DB       #40,#7F,#08,#C3,#00,#2B,#00,#D5       ;@..C.+.U
       DB       #00,#29,#E0,#78,#28,#C3,#00,#6B       ;.)`x(C.k
       DB       #C8,#CD,#00,#2F,#60,#7F,#88,#C3       ;HM./`..C
       DB       #00,#7F,#C0,#CB,#00,#2E,#C0,#7F       ;..@K..@.
       DB       #48,#C3,#00,#7F,#E0,#CB,#00,#2A       ;HC..`K.*
       DB       #E0,#7C,#00,#C3,#00,#7F,#A0,#CB       ;`|.C.. K
       DB       #00,#7F,#80,#CB,#00,#83,#3C,#72       ;...K..<r
       DB       #72,#79,#00,#C8,#00,#83,#72,#72       ;ry.H..rr
       DB       #7E,#C0,#72,#F7,#00,#7F,#C0,#CB       ;~@rw..@K
       DB       #00,#82,#7C,#0E,#04,#37,#81,#7C       ;..|..7.|
       DB       #D7,#00,#7E,#E8,#CB,#00,#7A,#58       ;W.~hK.zX
       DB       #EB,#00,#7A,#00,#CB,#00,#2D,#80       ;k.z.K.-.
       DB       #CD,#00,#24,#D8,#8F,#FF,#F8,#E0       ;M.$X..x`
       DB       #C0,#C0,#80,#80,#81,#80,#80,#C0       ;@@.....@
       DB       #C0,#E0,#F8,#FF,#C7,#00,#27,#C0       ;@`x.G.'@
       DB       #86,#FF,#F8,#F3,#E4,#E8,#C8,#C4       ;..xsdhHD
       DB       #D0,#82,#C0,#FF,#C7,#00,#2F,#20       ;P.@.G./ 
       DB       #84,#3E,#0E,#06,#06,#C2,#02,#85       ;.>...B..
       DB       #06,#06,#0E,#3E,#FE,#C7,#00,#17       ;...>~G..
       DB       #A0,#86,#7C,#00,#FE,#3E,#9E,#0E       ; .|.~>..
       DB       #00,#22,#C4,#06,#81,#FE,#C7,#00       ;."D..~G.
       DB       #81,#3E,#C2,#70,#D7,#00,#82,#72       ;.>BpW..r
       DB       #72,#1D,#98,#D5,#00,#82,#72,#72       ;r..U..rr
       DB       #1F,#70,#2F,#38,#68,#E8,#2F,#D8       ;.p/8hh/X
       DB       #7E,#A0,#C3,#00,#2D,#F0,#2F,#40       ;~ C.-p/@
       DB       #6F,#80,#2D,#58,#7A,#80,#C3,#00       ;o.-Xz.C.
       DB       #81,#3E,#2D,#38,#66,#88,#CD,#00       ;.>-8f.M.
       DB       #7B,#E0,#C3,#00,#2F,#20,#81,#3E       ;{`C./ .>
       DB       #27,#C0,#7C,#08,#7B,#00,#7B,#B8       ;'@|.{.{8
       DB       #82,#00,#00,#6F,#08,#CD,#00,#79       ;...o.M.y
       DB       #48,#C3,#00,#88,#3C,#72,#72,#7E       ;HC..<rr~
       DB       #72,#72,#00,#00,#27,#60,#81,#08       ;rr..'`..
       DB       #7D,#88,#7B,#E0,#C9,#00,#88,#3E       ;}.{`I..>
       DB       #4E,#4E,#3E,#4E,#4E,#00,#00,#7C       ;NN>NN..|
       DB       #C0,#CB,#00,#7D,#20,#CB,#00,#31       ;@K.} K.1
       DB       #C0,#7B,#48,#DA,#00,#3E,#E0,#2C       ;@{HZ.>`,
       DB       #A0,#7C,#C8,#C1,#00,#7C,#B8,#C3       ; |HA.|8C
       DB       #00,#81,#3E,#61,#78,#6F,#E0,#7E       ;..>axo`~
       DB       #C8,#76,#78,#17,#E0,#2F,#18,#86       ;Hvx.`/..
       DB       #3E,#70,#7C,#70,#70,#3E,#E7,#00       ;>p|pp>g.
       DB       #6F,#78,#23,#90,#CE,#00,#7E,#60       ;ox#.N.~`
       DB       #C3,#00,#2F,#18,#2F,#E8,#7F,#28       ;C././h.(
       DB       #7E,#60,#7D,#B8,#C7,#00,#81,#3E       ;~`}8G..>
       DB       #7F,#68,#3B,#28,#81,#3C,#CF,#00       ;.h;(.<O.
       DB       #2F,#18,#33,#28,#7F,#88,#7B,#E8       ;/.3(..{h
       DB       #7C,#F8,#81,#00,#31,#80,#7F,#08       ;|x..1...
       DB       #C2,#00,#7F,#38,#C3,#00,#42,#C0       ;B..8C.B@
       DB       #7F,#00,#C7,#00,#7A,#D8,#C4,#00       ;..G.zXD.
       DB       #14,#17,#83,#3E,#02,#00,#2F,#00       ;...>../.
       DB       #7D,#E8,#DB,#00,#2F,#18,#7F,#D8       ;}h[./..X
       DB       #CB,#00,#7E,#F8,#C3,#00,#2B,#40       ;K.~xC.+@
       DB       #2F,#58,#7F,#A0,#C3,#00,#7F,#F8       ;/X. C..x
       DB       #CB,#00,#8A,#3C,#72,#72,#7E,#72       ;K..<rr~r
       DB       #72,#00,#00,#7C,#70,#7D,#E8,#C1       ;r..|p}hA
       DB       #00,#7F,#F8,#D3,#00,#7C,#A8,#C3       ;..xS.|(C
       DB       #00,#7E,#40,#CB,#00,#40,#C0,#7F       ;.~@K.@@.
       DB       #88,#C0,#00,#7F,#C0,#CB,#00,#2F       ;.@..@K./
       DB       #C0,#7F,#08,#C3,#00,#7F,#C0,#D3       ;@..C..@S
       DB       #00,#7F,#E8,#C3,#00,#81,#70,#79       ;..hC..py
       DB       #18,#D2,#00,#7D,#C0,#FF,#00,#FF       ;.R.}@...
       DB       #00,#FF,#00,#67,#FA,#DD,#42,#DD       ;...gz]B]
       DB       #44,#82,#45,#45,#DB,#47,#78,#20       ;D.EE[Gx 
       DB       #58,#30,#FD,#44,#82,#47,#47,#DB       ;X0}D.GG[
       DB       #46,#78,#20,#58,#30,#FD,#44,#78       ;Fx X0}Dx
       DB       #80,#78,#80,#D9,#46,#FD,#44,#00       ;.x.YF}D.
       DB       #C2,#00,#C5,#82,#46,#46,#D5,#45       ;B.E.FFUE
       DB       #78,#20,#58,#2A,#FD,#44,#79,#80       ;x X*}Dy.
       DB       #79,#80,#D9,#46,#FD,#44,#7A,#00       ;y.YF}Dz.
       DB       #7A,#00,#D9,#46,#80       ;z.YF.
;
DepackHelp3
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_9942	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_9981
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_995C	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_9976
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_9976	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_995C
	POP	HL
	JR	L_9942
;
L_9981	AND	#7F
	JR	Z,L_99A2
	INC	HL
	BIT	6,A
	JR	NZ,L_9994
	LD	B,A
L_998B	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_998B
	JR	L_9942
;
L_9994	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_999A	CALL	L_74A6
	DJNZ	L_999A
	INC	HL
	JR	L_9942
;
L_99A2	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#8E       ;.....YI.
       DB       #00,#7C,#0E,#3C,#0E,#0E,#7C,#00       ;.|.<..|.
       DB       #FF,#F8,#E0,#C1,#C7,#C7,#C4,#CF       ;.x`AGGDO
       DB       #82,#C0,#FF,#C7,#00,#C0,#4E,#92       ;.@.G.@N.
       DB       #3E,#0E,#0E,#00,#FF,#80,#BF,#A0       ;>.....? 
       DB       #D0,#E8,#F4,#FA,#F4,#E9,#D7,#BF       ;PhtztiW?
       DB       #BF,#80,#40,#20,#8A,#3C,#72,#72       ;?.@ .<rr
       DB       #7E,#72,#72,#00,#FE,#3E,#0E,#C1       ;~rr.~>.A
       DB       #F6,#83,#D6,#96,#D6,#00,#07,#82       ;v.V.V...
       DB       #06,#FE,#78,#20,#8D,#02,#FA,#0A       ;.~x ..z.
       DB       #16,#2E,#5E,#BE,#5E,#2E,#D6,#FA       ;..^>^.Vz
       DB       #FA,#02,#40,#20,#83,#72,#72,#7C       ;z.@ .rr|
       DB       #C0,#72,#D7,#00,#81,#3E,#C1,#70       ;@rW..>Ap
       DB       #81,#3E,#D7,#00,#00,#3E,#88,#7C       ;.>W..>.|
       DB       #70,#70,#00,#00,#71,#7B,#75,#C0       ;pp..q{u@
       DB       #71,#83,#00,#00,#7F,#C2,#1C,#60       ;q....B.`
       DB       #60,#84,#7C,#00,#00,#7E,#C2,#4E       ;`.|..~BN
       DB       #78,#68,#28,#20,#00,#C8,#83,#72       ;xh( .H.r
       DB       #72,#3C,#28,#08,#78,#90,#28,#68       ;r<(.x.(h
       DB       #68,#AA,#28,#70,#83,#5D,#5D,#3E       ;h*(p.]]>
       DB       #C0,#5D,#00,#B0,#78,#68,#20,#E8       ;@].0xh h
       DB       #82,#76,#7A,#78,#E8,#31,#40,#01       ;.vzxh1@.
       DB       #08,#01,#47,#01,#08,#82,#70,#70       ;..G...pp
       DB       #18,#B0,#70,#E8,#78,#18,#19,#20       ;.0phx.. 
       DB       #01,#A0,#08,#D8,#28,#C0,#79,#50       ;. .X(@yP
       DB       #58,#68,#DD,#00,#79,#00,#29,#68       ;Xh].y.)h
       DB       #78,#98,#0A,#26,#81,#1E,#C1,#2E       ;x..&..A.
       DB       #82,#7E,#42,#79,#60,#78,#A8,#79       ;.~By`x(y
       DB       #80,#40,#58,#29,#C8,#79,#F0,#58       ;.@X)HypX
       DB       #E8,#7A,#20,#01,#FF,#02,#20,#79       ;hz ... y
       DB       #B8,#5A,#54,#81,#76,#C1,#79,#81       ;8ZT.vAy.
       DB       #76,#7A,#68,#22,#40,#81,#08,#29       ;vzh"@..)
       DB       #A0,#7A,#90,#59,#E8,#6A,#AA,#29       ; z.Yhj*)
       DB       #B0,#2A,#78,#7A,#00,#E3,#00,#2A       ;0*xz.c.*
       DB       #20,#78,#A8,#1B,#8C,#82,#1C,#3C       ; x(....<
       DB       #02,#D9,#81,#7E,#DF,#00,#23,#B0       ;.Y.~_.#0
       DB       #7A,#68,#0A,#80,#7A,#D8,#7B,#70       ;zh..zX{p
       DB       #21,#50,#7A,#A8,#78,#40,#D1,#00       ;!Pz(x@Q.
       DB       #2B,#88,#FF,#00,#79,#E8,#7C,#08       ;+...yh|.
       DB       #34,#40,#8B,#AA,#7F,#FC,#7B,#FB       ;4@.*.|{{
       DB       #7B,#FC,#7E,#FE,#7E,#FE,#00,#04       ;{|~~~~..
       DB       #44,#C0,#6A,#A8,#7B,#40,#14,#18       ;D@j({@..
       DB       #83,#AA,#FE,#7E,#C0,#BE,#81,#7E       ;.*~~@>.~
       DB       #C0,#FE,#84,#3E,#7E,#3E,#FE,#44       ;@~.>~>~D
       DB       #C0,#7B,#C0,#7A,#58,#7A,#58,#7C       ;@{@zXzX|
       DB       #D0,#2B,#E0,#79,#B0,#19,#B0,#78       ;P+`y0.0x
       DB       #A0,#7C,#40,#7D,#28,#7B,#60,#D5       ; |@}({`U
       DB       #00,#14,#FF,#82,#3E,#02,#D6,#00       ;....>.V.
       DB       #7B,#60,#FF,#00,#7C,#40,#D7,#00       ;{`..|@W.
       DB       #79,#A0,#7D,#E8,#7D,#80,#7C,#A0       ;y }h}.| 
       DB       #D5,#00,#7A,#D8,#7C,#48,#7E,#68       ;U.zX|H~h
       DB       #7A,#D8,#D5,#00,#7E,#20,#7C,#A8       ;zXU.~ |(
       DB       #7E,#C8,#7E,#20,#D5,#00,#7A,#40       ;~H~ U.z@
       DB       #EB,#00,#7E,#80,#7D,#F0,#0F,#F6       ;k.~.}p.v
       DB       #2F,#28,#27,#50,#81,#7F,#DD,#00       ;/('P..].
       DB       #6F,#58,#67,#48,#7B,#8A,#7F,#18       ;oXgH{...
       DB       #57,#18,#2E,#C0,#27,#D0,#7B,#CA       ;W..@'P{J
       DB       #CC,#00,#6E,#30,#2F,#50,#26,#18       ;L.n0/P&.
       DB       #7C,#0A,#CC,#00,#6F,#18,#85,#7C       ;|.L.o..|
       DB       #0E,#3C,#0E,#0E,#07,#80,#27,#90       ;.<....'.
       DB       #7C,#4A,#CC,#00,#6B,#D8,#17,#80       ;|JL.kX..
       DB       #3E,#10,#7C,#8A,#CC,#00,#6C,#58       ;>.|.L.lX
       DB       #67,#68,#81,#FF,#DC,#08,#82,#00       ;gh..\...
       DB       #3E,#65,#B0,#2F,#E8,#16,#08,#79       ;>e0/h..y
       DB       #80,#DE,#00,#2F,#50,#27,#D0,#7D       ;.^./P'P}
       DB       #4A,#CC,#00,#6C,#D8,#2F,#28,#27       ;JL.lX/('
       DB       #D0,#7D,#8A,#CC,#00,#7D,#58,#86       ;P}.L.}X.
       DB       #00,#00,#18,#18,#30,#00,#21,#C8       ;....0.!H
       DB       #35,#CA,#2A,#98,#2A,#A0,#2D,#50       ;5J*.* -P
       DB       #83,#5D,#5D,#3E,#C0,#5D,#C7,#00       ;.]]>@]G.
       DB       #2F,#C0,#24,#70,#36,#0A,#2A,#E8       ;/@$p6.*h
       DB       #2F,#A0,#2A,#28,#6D,#98,#2F,#00       ;/ *(m./.
       DB       #27,#C8,#36,#4A,#2A,#98,#2F,#A8       ;'H6J*./(
       DB       #03,#35,#15,#D0,#6F,#30,#2F,#00       ;.5.Po0/.
       DB       #25,#50,#48,#80,#12,#98,#29,#20       ;%PH...) 
       DB       #30,#90,#C2,#70,#CF,#00,#6A,#C0       ;0.BpO.j@
       DB       #3A,#98,#1B,#20,#2E,#D0,#6B,#C0       ;:.. .Pk@
       DB       #2D,#68,#6A,#80,#2A,#98,#2F,#E0       ;-hj.*./`
       DB       #7E,#D0,#C3,#00,#60,#28,#38,#80       ;~PC.`(8.
       DB       #81,#72,#5D,#C0,#29,#E8,#7F,#F0       ;.r]@)h.p
       DB       #57,#FC,#71,#00,#2E,#08,#2B,#B8       ;W|q...+8
       DB       #6F,#D8,#6B,#00,#C5,#00,#86,#3E       ;oXk.E..>
       DB       #70,#7C,#70,#70,#3E,#C7,#00,#2E       ;p|pp>G..
       DB       #B0,#82,#72,#72,#7F,#58,#78,#80       ;0.rr.Xx.
       DB       #82,#00,#00,#2A,#98,#6F,#68,#6F       ;...*.oho
       DB       #C0,#67,#88,#54,#C0,#42,#98,#81       ;@g.T@B..
       DB       #00,#2F,#B0,#82,#18,#18,#0A,#B0       ;./0....0
       DB       #C7,#00,#64,#50,#42,#40,#81,#7E       ;G.dPB@.~
       DB       #C0,#72,#82,#00,#00,#2D,#C8,#7E       ;@r...-H~
       DB       #D0,#7D,#E8,#C0,#00,#72,#40,#2E       ;P}h@.r@.
       DB       #08,#6C,#B8,#7E,#28,#C2,#00,#75       ;.l8~(B.u
       DB       #80,#2C,#A0,#2D,#68,#CD,#00,#2C       ;., -hM.,
       DB       #C0,#C4,#00,#6B,#00,#81,#08,#2E       ;@D.k....
       DB       #A8,#6E,#38,#C4,#00,#30,#20,#C4       ;(n8D.0 D
       DB       #00,#81,#FE,#C5,#00,#6D,#68,#7E       ;..~E.mh~
       DB       #D0,#DB,#00,#66,#18,#EE,#00,#66       ;P[.f.n.f
       DB       #98,#ED,#00,#30,#F8,#7A,#F0,#EB       ;.m.0xzpk
       DB       #00,#6D,#B0,#ED,#00,#7A,#F0,#EB       ;.m0m.zpk
       DB       #00,#2D,#A0,#F1,#00,#89,#FF,#80       ;.- q....
       DB       #80,#95,#8A,#97,#8F,#97,#8F,#08       ;........
       DB       #04,#82,#97,#80,#7F,#DC,#D7,#00       ;.....\W.
       DB       #89,#7F,#40,#40,#4A,#45,#4B,#47       ;..@@JEKG
       DB       #4B,#47,#08,#04,#28,#08,#83,#4B       ;KG..(..K
       DB       #40,#7F,#E5,#00,#07,#C8,#82,#AA       ;@.e..H.*
       DB       #55,#C4,#FF,#81,#FE,#C6,#FF,#81       ;UD..~F..
       DB       #00,#7F,#DF,#D4,#00,#18,#40,#8D       ;.._T..@.
       DB       #FB,#F1,#E0,#FB,#BB,#3B,#00,#3B       ;{q`{;;.;
       DB       #BB,#FB,#E0,#F1,#FB,#78,#40,#D8       ;;{`q{x@X
       DB       #00,#20,#80,#C0,#FE,#85,#BE,#9E       ;. .@~.>.
       DB       #0E,#9E,#BE,#00,#08,#78,#80,#D9       ;..>..x.Y
       DB       #00,#20,#C0,#82,#00,#00,#2E,#A0       ;. @.... 
       DB       #81,#AA,#18,#C0,#E0,#08,#84,#7F       ;.*.@`...
       DB       #3E,#1C,#08,#38,#40,#27,#D8,#28       ;>..8@'X(
       DB       #40,#E5,#00,#30,#80,#2C,#78,#68       ;@e.0.,xh
       DB       #40,#27,#20,#79,#91,#C3,#00,#30       ;@' y.C.0
       DB       #C0,#2D,#B8,#68,#80,#25,#D0,#7F       ;@-8h.%P.
       DB       #F0,#C3,#00,#31,#00,#2F,#88,#21       ;pC.1./.!
       DB       #00,#32,#01,#6E,#B0,#7E,#48,#78       ;.2.n0~Hx
       DB       #C0,#02,#00,#6F,#60,#7A,#94,#C3       ;@..o`z.C
       DB       #00,#22,#40,#84,#3F,#7F,#3F,#7F       ;."@.?.?.
       DB       #08,#04,#83,#3F,#7F,#BF,#60,#40       ;...?.?`@
       DB       #27,#38,#7A,#D4,#C3,#00,#3A,#80       ;'8zTC.:.
       DB       #C2,#FE,#32,#80,#37,#E0,#C2,#75       ;B~2.7`Bu
       DB       #79,#00,#5A,#C0,#8D,#E0,#83,#0F       ;y.Z@.`..
       DB       #3B,#3B,#7B,#7B,#7D,#7E,#3F,#3F       ;;;{{}~??
       DB       #9F,#E0,#58,#C0,#6F,#F0,#7F,#48       ;.`X@op.H
       DB       #0B,#00,#83,#3E,#DE,#DE,#C2,#EE       ;...>^^Bn
       DB       #83,#5E,#DE,#3E,#61,#00,#78,#40       ;.^^>a.x@
       DB       #7B,#40,#12,#00,#87,#0E,#0E,#3C       ;{@.....<
       DB       #70,#7E,#00,#00,#69,#40,#29,#C0       ;p~..i@)@
       DB       #CF,#10,#85,#FE,#7C,#38,#10,#00       ;O..~|8..
       DB       #5A,#80,#83,#0E,#00,#00,#70,#40       ;Z.....p@
       DB       #1F,#90,#7C,#14,#C3,#00,#33,#00       ;..|.C.3.
       DB       #82,#1C,#3C,#07,#89,#78,#80,#C5       ;..<..x.E
       DB       #00,#7C,#54,#C3,#00,#79,#C0,#79       ;.|TC.y@y
       DB       #C0,#51,#C0,#26,#E0,#2C,#61,#1C       ;@Q@&`,a.
       DB       #40,#81,#FC,#C0,#FB,#81,#FC,#C5       ;@.|@{.|E
       DB       #FE,#6A,#00,#17,#90,#48,#D0,#03       ;~j...HP.
       DB       #6B,#82,#00,#FF,#C4,#00,#1C,#80       ;k...D...
       DB       #81,#7F,#C0,#BE,#81,#7E,#0A,#01       ;..@>.~..
       DB       #82,#3E,#7E,#79,#80,#59,#C0,#81       ;.>~y.Y@.
       DB       #76,#C1,#79,#83,#76,#00,#FF,#69       ;vAy.v..i
       DB       #40,#85,#7C,#0E,#3C,#0E,#0E,#07       ;@.|.<...
       DB       #80,#6A,#C0,#26,#D8,#37,#F0,#21       ;.j@&X7p!
       DB       #68,#81,#FF,#C4,#00,#7A,#C0,#79       ;h..D.z@y
       DB       #80,#09,#80,#37,#70,#27,#A8,#2F       ;...7p'(/
       DB       #80,#85,#FE,#02,#02,#AA,#52,#CE       ;..~..*RN
       DB       #FA,#82,#02,#FE,#7D,#C4,#D8,#00       ;z..~}DX.
       DB       #07,#CD,#82,#AA,#54,#C6,#FE,#17       ;.M.*TF~.
       DB       #DC,#7E,#04,#D3,#00,#5E,#3B,#3E       ;\~.S.^;>
       DB       #43,#7E,#44,#D3,#00,#00,#D8,#82       ;C~DS..X.
       DB       #54,#AA,#C8,#FE,#33,#80,#DF,#01       ;T*H~3._.
       DB       #8A,#0F,#07,#03,#01,#00,#AA,#7F       ;......*.
       DB       #FF,#7F,#FF,#08,#04,#18,#08,#81       ;........
       DB       #00,#1E,#4C,#81,#00,#78,#80,#CF       ;..L..x.O
       DB       #00,#85,#E0,#C0,#80,#00,#00,#48       ;..`@...H
       DB       #7C,#08,#FC,#78,#40,#DB,#00,#22       ;|.|x@[."
       DB       #40,#40,#85,#7B,#00,#D9,#00,#79       ;@@.{.Y.y
       DB       #C0,#79,#C0,#DE,#00,#01,#2D,#82       ;@y@^..-.
       DB       #55,#A9,#C6,#FD,#81,#01,#0F,#C0       ;U)F}...@
       DB       #DD,#44,#82,#47,#47,#CE,#46,#50       ;]D.GGNFP
       DB       #13,#78,#20,#58,#20,#FD,#44,#78       ;.x X }Dx
       DB       #80,#78,#8D,#F9,#46,#FD,#42,#FF       ;.x.yF}B.
       DB       #47,#E2,#47,#D6,#46,#78,#20,#78       ;GbGVFx x
       DB       #20,#78,#40,#78,#40,#D5,#46,#28       ; x@x@UF(
       DB       #E0,#CD,#45,#78,#20,#78,#20,#78       ;`MEx x x
       DB       #40,#08,#46,#1A,#72,#78,#60,#78       ;@.F.rx`x
       DB       #20,#0A,#7A,#81,#05,#D4,#07,#00       ; .z..T..
       DB       #18,#82,#06,#06,#00,#07,#10,#20       ;....... 
       DB       #C3,#06,#20,#0A,#08,#10,#60,#20       ;C. ...` 
       DB       #D0,#07,#20,#58,#81,#05,#80       ;P. X...
;
DepackHelp4
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_9F54	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_9F93
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_9F6E	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_9F88
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_9F88	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_9F6E
	POP	HL
	JR	L_9F54
;
L_9F93	AND	#7F
	JR	Z,L_9FB4
	INC	HL
	BIT	6,A
	JR	NZ,L_9FA6
	LD	B,A
L_9F9D	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_9F9D
	JR	L_9F54
;
L_9FA6	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_9FAC	CALL	L_74A6
	DJNZ	L_9FAC
	INC	HL
	JR	L_9F54
;
L_9FB4	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#8E       ;.....YI.
       DB       #00,#7C,#0E,#3C,#0E,#0E,#7C,#00       ;.|.<..|.
       DB       #00,#7C,#72,#7C,#72,#72,#00,#08       ;.|r|rr..
       DB       #81,#7E,#C2,#4E,#82,#00,#00,#00       ;.~BN....
       DB       #07,#83,#3E,#0E,#3C,#38,#18,#83       ;..>.<8..
       DB       #72,#72,#7E,#C0,#72,#85,#00,#00       ;rr~@r...
       DB       #71,#7B,#75,#C0,#71,#38,#20,#81       ;q{u@q8 .
       DB       #3C,#10,#19,#28,#08,#83,#00,#00       ;<..(....
       DB       #3E,#20,#40,#28,#48,#C5,#00,#84       ;> @(HE..
       DB       #72,#72,#76,#7A,#10,#20,#85,#70       ;rrvz. .p
       DB       #7C,#70,#70,#3E,#38,#68,#81,#1E       ;|pp>8h..
       DB       #C1,#2E,#83,#7E,#42,#00,#C2,#75       ;A..~B.Bu
       DB       #00,#18,#28,#28,#08,#8E,#82,#70       ;..((...p
       DB       #70,#40,#38,#00,#90,#08,#98,#28       ;p@8....(
       DB       #88,#28,#20,#68,#80,#81,#7F,#C2       ;.( h...B
       DB       #1C,#40,#90,#C2,#70,#84,#00,#00       ;.@.Bp...
       DB       #18,#18,#08,#04,#38,#48,#28,#B8       ;....8H(8
       DB       #10,#E8,#81,#0E,#48,#A8,#01,#08       ;.h..H(..
       DB       #10,#80,#19,#10,#28,#88,#28,#A8       ;....(.((
       DB       #81,#76,#C1,#79,#81,#76,#39,#30       ;.vAy.v90
       DB       #29,#00,#29,#48,#69,#08,#28,#F0       ;).)Hi.(p
       DB       #28,#D0,#28,#A0,#29,#28,#29,#22       ;(P( )()"
       DB       #29,#48,#29,#60,#29,#28,#68,#20       ;)H)`)(h 
       DB       #10,#D0,#01,#40,#68,#20,#29,#48       ;.P.@h )H
       DB       #39,#70,#19,#B0,#29,#70,#28,#D8       ;9p.0)p(X
       DB       #69,#48,#68,#80,#29,#00,#39,#B0       ;iHh.).90
       DB       #18,#70,#01,#E8,#82,#72,#72,#02       ;.p.h.rr.
       DB       #10,#69,#D0,#29,#E2,#69,#48,#29       ;.iP)biH)
       DB       #E8,#29,#90,#2A,#40,#68,#98,#69       ;h).*@h.i
       DB       #00,#2A,#88,#2A,#3A,#82,#70,#70       ;.*.*:.pp
       DB       #31,#68,#10,#80,#2A,#70,#D5,#00       ;1h..*pU.
       DB       #11,#C0,#40,#40,#2A,#82,#2A,#B8       ;.@@@*.*8
       DB       #83,#5D,#5D,#3E,#C0,#5D,#79,#30       ;.]]>@]y0
       DB       #2A,#F8,#00,#E5,#51,#18,#69,#58       ;*x.eQ.iX
       DB       #38,#A8,#1A,#A0,#2A,#E2,#42,#90       ;8(. *bB.
       DB       #51,#28,#3B,#40,#1B,#00,#6A,#A0       ;Q(;@..j 
       DB       #42,#00,#11,#60,#1B,#10,#7A,#18       ;B..`..z.
       DB       #6B,#48,#2A,#A8,#68,#68,#2B,#B8       ;kH*(hh+8
       DB       #79,#18,#22,#00,#23,#80,#69,#D0       ;y.".#.iP
       DB       #6A,#70,#68,#D8,#2C,#10,#2C,#00       ;jphX,.,.
       DB       #6A,#40,#2A,#98,#69,#9A,#6B,#00       ;j@*.i.k.
       DB       #68,#F0,#2C,#22,#2B,#B8,#69,#DA       ;hp,"+8iZ
       DB       #29,#B0,#2A,#F8,#2B,#A0,#2C,#88       ;)0*x+ ,.
       DB       #7A,#90,#6A,#10,#1C,#78,#2A,#C0       ;z.j..x*@
       DB       #6B,#78,#DD,#00,#2C,#F0,#6C,#70       ;kx].,plp
       DB       #6A,#82,#6B,#80,#6B,#D8,#2B,#40       ;j.k.kX+@
       DB       #6A,#E0,#6A,#40,#D5,#00,#39,#78       ;j`j@U.9x
       DB       #78,#E8,#7A,#28,#63,#98,#23,#B8       ;xhz(c.#8
       DB       #83,#18,#18,#30,#35,#68,#7B,#38       ;...05h{8
       DB       #5A,#50,#6B,#18,#7B,#F8,#70,#E8       ;ZPk.{xph
       DB       #54,#20,#6B,#18,#2D,#58,#83,#36       ;T k.-X.6
       DB       #36,#6C,#D2,#00,#6C,#90,#79,#40       ;6lR.l.y@
       DB       #24,#00,#81,#70,#1E,#B0,#79,#68       ;$..p.0yh
       DB       #7C,#18,#4B,#80,#2E,#18,#79,#68       ;|.K...yh
       DB       #DB,#00,#2E,#D0,#7C,#80,#79,#28       ;[..P|.y(
       DB       #7A,#58,#7E,#00,#7B,#28,#7B,#10       ;zX~.{({.
       DB       #62,#42,#15,#76,#2C,#D8,#7B,#A8       ;bB.v,X{(
       DB       #E3,#00,#2F,#78,#69,#80,#2F,#80       ;c./xi./.
       DB       #2F,#38,#81,#7E,#C2,#4E,#82,#00       ;/8.~BN..
       DB       #00,#2E,#68,#2F,#E8,#2F,#B8,#2F       ;..h/h/8/
       DB       #B0,#2F,#B8,#69,#E0,#81,#3E,#65       ;0/8i`.>e
       DB       #F8,#68,#50,#6F,#58,#6F,#C0,#6D       ;xhPoXo@m
       DB       #48,#31,#38,#C2,#4E,#84,#00,#00       ;H18BN...
       DB       #72,#72,#33,#D0,#56,#B0,#6F,#38       ;rr3PV0o8
       DB       #6B,#B0,#56,#D0,#42,#90,#6E,#D8       ;k0VPB.nX
       DB       #2F,#E8,#7B,#B0,#7B,#D0,#81,#72       ;/h{0{P.r
       DB       #07,#10,#3E,#D8,#1F,#60,#3D,#F0       ;..>X.`=p
       DB       #27,#80,#27,#E8,#82,#7C,#72,#1E       ;'.'h.|r.
       DB       #D8,#81,#76,#C1,#79,#83,#76,#00       ;X.vAy.v.
       DB       #00,#6F,#80,#3B,#28,#45,#E0,#41       ;.o.;(E`A
       DB       #F0,#88,#3C,#72,#72,#7E,#72,#72       ;p.<rr~rr
       DB       #00,#00,#13,#C0,#83,#3F,#01,#00       ;...@.?..
       DB       #2F,#B0,#2E,#B8,#34,#E0,#20,#E0       ;/0.84` `
       DB       #6B,#58,#2F,#00,#6C,#10,#2F,#A8       ;kX/.l./(
       DB       #2F,#20,#69,#58,#6F,#E8,#28,#C0       ;/ iXoh(@
       DB       #6E,#F8,#6F,#F0,#6A,#38,#83,#72       ;nxopj8.r
       DB       #72,#7E,#C0,#72,#82,#00,#00,#2E       ;r~@r....
       DB       #28,#2F,#08,#6E,#78,#2F,#F0,#6F       ;(/.nx/po
       DB       #A0,#2E,#B8,#05,#C0,#05,#C3,#82       ; .8.@.C.
       DB       #00,#00,#2F,#68,#39,#F8,#5E,#80       ;../h9x^.
       DB       #6A,#20,#7C,#A0,#5E,#F8,#2F,#98       ;j | ^x/.
       DB       #6F,#F0,#2F,#50,#81,#7C,#20,#98       ;op/P.| .
       DB       #2D,#10,#2D,#18,#29,#90,#3E,#E8       ;-.-.).>h
       DB       #58,#28,#82,#7C,#72,#2D,#00,#0F       ;X(.|r-..
       DB       #E2,#82,#00,#00,#7C,#50,#2A,#C8       ;b...|P*H
       DB       #2A,#48,#66,#B0,#27,#58,#3A,#70       ;*Hf0'X:p
       DB       #86,#76,#7A,#72,#72,#00,#00,#2F       ;.vzrr../
       DB       #70,#4F,#B8,#19,#D0,#7A,#E0,#0F       ;pO8.Pz`.
       DB       #E8,#6B,#E8,#2F,#08,#6F,#78,#7B       ;hkh/.ox{
       DB       #90,#86,#72,#7C,#70,#70,#00,#00       ;..r|pp..
       DB       #52,#98,#43,#E8,#40,#A0,#17,#18       ;R.Ch@ ..
       DB       #2A,#E0,#82,#7C,#0E,#1D,#A8,#69       ;*`.|..(i
       DB       #A8,#4E,#90,#25,#60,#11,#D0,#2F       ;(N.%`.P/
       DB       #FA,#2A,#E0,#2C,#F0,#42,#98,#56       ;z*`,pB.V
       DB       #60,#6E,#30,#2D,#E0,#2F,#F0,#7F       ;`n0-`/p.
       DB       #68,#27,#68,#22,#60,#7B,#40,#1F       ;h'h"`{@.
       DB       #D8,#6B,#70,#6F,#08,#2D,#D0,#83       ;Xkpo.-P.
       DB       #5D,#5D,#3E,#C0,#5D,#82,#00,#00       ;]]>@]...
       DB       #3C,#08,#2D,#00,#1D,#E0,#6B,#28       ;<.-..`k(
       DB       #36,#08,#39,#18,#57,#B0,#28,#50       ;6.9.W0(P
       DB       #2A,#E0,#69,#98,#6E,#B8,#3E,#D0       ;*`i.n8>P
       DB       #7E,#18,#D1,#00,#2E,#88,#2F,#D0       ;~.Q.../P
       DB       #6A,#48,#78,#E8,#5E,#A8,#6D,#18       ;jHxh^(m.
       DB       #2B,#88,#6C,#40,#7A,#58,#5F,#88       ;+.l@zX_.
       DB       #2D,#A8,#C5,#00,#69,#E0,#39,#C0       ;-(E.i`9@
       DB       #5F,#A8,#6B,#18,#2E,#70,#C5,#00       ;_(k..pE.
       DB       #29,#90,#7C,#58,#5D,#08,#33,#B0       ;).|X].30
       DB       #63,#C8,#3C,#A8,#26,#C8,#67,#D0       ;cH<(&HgP
       DB       #2F,#08,#6E,#80,#6B,#48,#6B,#28       ;/.n.kHk(
       DB       #6A,#A0,#69,#10,#6D,#60,#C5,#00       ;j i.m`E.
       DB       #6D,#78,#2D,#18,#78,#20,#81,#3C       ;mx-.x .<
       DB       #54,#D6,#7A,#F8,#D5,#00,#18,#38       ;TVzxU..8
       DB       #16,#50,#45,#A0,#2F,#B8,#3E,#E0       ;.PE /8>`
       DB       #24,#B8,#87,#70,#7C,#70,#70,#3E       ;$8.p|pp>
       DB       #00,#00,#3B,#68,#5E,#20,#82,#72       ;..;h^ .r
       DB       #72,#2F,#60,#86,#7C,#70,#70,#3E       ;r/`.|pp>
       DB       #00,#00,#2F,#68,#6C,#C8,#36,#18       ;../hlH6.
       DB       #27,#D0,#83,#36,#36,#6C,#26,#A8       ;'P.66l&(
       DB       #59,#D0,#81,#3C,#C1,#72,#83,#3C       ;YP.<Ar.<
       DB       #00,#00,#2F,#90,#81,#3E,#C2,#4E       ;../..>BN
       DB       #82,#00,#00,#6C,#A0,#82,#3C,#70       ;...l .<p
       DB       #5B,#50,#3F,#90,#5D,#50,#88,#72       ;[P?.]P.r
       DB       #72,#76,#7A,#72,#72,#00,#00,#17       ;rvzrr...
       DB       #8F,#83,#3E,#02,#00,#2F,#D8,#6E       ;..>../Xn
       DB       #C0,#2F,#E0,#2E,#88,#6A,#B0,#68       ;@/`..j0h
       DB       #F0,#2F,#98,#6D,#48,#76,#40,#88       ;p/.mHv@.
       DB       #72,#7C,#72,#72,#7C,#00,#00,#76       ;r|rr|..v
       DB       #C1,#79,#83,#76,#00,#00,#29,#78       ;Ay.v..)x
       DB       #6E,#B8,#82,#72,#72,#5E,#08,#2F       ;n8.rr^./
       DB       #70,#2D,#10,#2F,#B8,#69,#70,#2F       ;p-./8ip/
       DB       #B0,#6D,#60,#DD,#00,#29,#80,#2F       ;0m`].)./
       DB       #B0,#2C,#D8,#3E,#C0,#5E,#F8,#2F       ;0,X>@^x/
       DB       #E0,#29,#B8,#2E,#78,#3E,#E8,#2F       ;`)8.x>h/
       DB       #E8,#5D,#48,#46,#F0,#56,#D8,#3F       ;h]HFpVX?
       DB       #E0,#5A,#20,#2F,#38,#2F,#E0,#2F       ;`Z /8/`/
       DB       #78,#7F,#E0,#1F,#38,#2F,#E0,#2E       ;x.`.8/`.
       DB       #80,#6D,#10,#83,#3C,#72,#72,#57       ;.m..<rrW
       DB       #68,#2F,#98,#6E,#E8,#6C,#F0,#37       ;h/.nhlp7
       DB       #68,#6A,#80,#22,#78,#4E,#62,#0F       ;hj."xNb.
       DB       #80,#69,#38,#6E,#98,#2E,#38,#6D       ;.i8n..8m
       DB       #00,#47,#10,#55,#A0,#6E,#F8,#37       ;.G.U nx7
       DB       #10,#81,#70,#1F,#60,#88,#3E,#70       ;..p.`.>p
       DB       #7C,#70,#70,#3E,#00,#00,#6B,#90       ;|pp>..k.
       DB       #2B,#80,#2F,#C0,#6C,#70,#39,#A8       ;+./@lp9(
       DB       #37,#C0,#17,#A8,#44,#00,#85,#7E       ;7@.(D..~
       DB       #72,#72,#00,#00,#6F,#78,#2F,#68       ;rr..ox/h
       DB       #17,#70,#83,#7F,#00,#00,#50,#10       ;.p....P.
       DB       #44,#18,#3D,#50,#21,#70,#27,#78       ;D.=P!p'x
       DB       #3C,#20,#07,#68,#5B,#78,#17,#E0       ;< .h[x.`
       DB       #2D,#68,#2F,#D0,#34,#30,#66,#E0       ;-h/P40f`
       DB       #7F,#20,#3F,#20,#0B,#20,#6F,#10       ;. ? . o.
       DB       #47,#78,#82,#72,#72,#07,#B0,#2C       ;Gx.rr.0,
       DB       #78,#2E,#D8,#4B,#60,#D1,#00,#2F       ;x.XK`Q./
       DB       #68,#2F,#08,#67,#98,#83,#08,#72       ;h/.g...r
       DB       #72,#69,#58,#6E,#80,#81,#7C,#25       ;riXn..|%
       DB       #F0,#5C,#98,#2E,#48,#6A,#D8,#7E       ;p\..HjX~
       DB       #C0,#1D,#88,#6A,#10,#2F,#08,#2F       ;@..j././
       DB       #60,#6A,#60,#C5,#00,#2F,#B8,#2F       ;`j`E./8/
       DB       #88,#2D,#78,#57,#50,#46,#90,#6E       ;.-xWPF.n
       DB       #48,#81,#1E,#C1,#2E,#83,#7E,#42       ;H..A..~B
       DB       #00,#6D,#30,#2F,#58,#7A,#D0,#6E       ;.m0/XzPn
       DB       #D0,#5C,#18,#40,#80,#20,#F0,#32       ;P\.@. p2
       DB       #88,#55,#C8,#C5,#00,#2F,#80,#78       ;.UHE./.x
       DB       #60,#C3,#00       ;`C.

      
        display "levels=",$
;levels??? #0052 one element
levels
       DB       #6F,#F8,#86,#3E,#70,#7C,#70,#70       ;ox.>p|pp
       DB       #3E,#C7,#00,#7C,#18,#5F,#88,#6D       ;>G.|._.m
       DB       #C8,#6B,#78,#6D,#A0,#79,#58,#5A       ;Hkxm yXZ
       DB       #E0,#2A,#F0,#C5,#00,#2F,#00,#69       ;`*pE./.i
       DB       #30,#2A,#98,#6F,#F0,#6F,#D8,#7C       ;0*.opoX|
       DB       #10,#68,#28,#58,#30,#CF,#00,#78       ;.h(X0O.x
       DB       #20,#C0,#00,#DD,#42,#FD,#47,#DD       ; @.]B}G]
       DB       #42,#FF,#47,#DB,#47,#DD,#42,#FF       ;B.G[G]B.
       DB       #46,#FB,#46,#DD,#42,#FF,#46,#FF       ;F{F]B.F.
       DB       #46,#FF,#46,#F7,#46,#FF,#43,#DB       ;F.FwF.C[
       DB       #43,#80
       db #00,#00,#01,#11,#11,#11       ;C.......
       DB       #11,#00,#00,#00,#01,#00,#00,#FF       ;........
       DB       #F1,#00,#00,#00,#01,#00,#00,#FF       ;q.......
       DB       #F1,#00,#00,#11,#11,#00,#0F,#FF       ;q.......
       DB       #F1,#00,#00,#10,#00,#00,#0F,#FF       ;q.......
       DB       #F1,#00,#00,#1F,#4F,#00,#8F,#11       ;q...O...
       DB       #11,#00,#00,#1F,#4F,#10,#8F,#10       ;....O...
       DB       #00,#00,#00,#1F,#4F,#10,#0F,#10       ;....O...
       DB       #00,#00,#00,#12,#4F,#F0,#8F,#10       ;....Op..
       DB       #00,#00,#00,#11,#11,#11,#11,#10       ;........
       DB       #00,#00,#01,#0C
       db #00,#00,#00,#00       ;........
       DB       #01,#11,#11,#11,#00,#00,#00,#11       ;........
       DB       #11,#BF,#FF,#F1,#11,#11,#11,#10       ;.?.q....
       DB       #00,#00,#00,#81,#1F,#4F,#00,#00       ;.....O..
       DB       #00,#00,#00,#01,#1F,#49,#00,#00       ;.....I..
       DB       #00,#00,#00,#11,#1F,#40,#00,#00       ;.....@..
       DB       #B1,#00,#0F,#F1,#11,#10,#0F,#F4       ;1..q...t
       DB       #F1,#00,#0F,#F1,#00,#10,#02,#F4       ;q..q...t
       DB       #F1,#00,#0F,#F1,#00,#11,#11,#11       ;q..q....
       DB       #11,#00,#00,#81,#00,#00,#00,#00       ;........
       DB       #01,#11,#11,#11,#05,#01
       db #00,#11       ;........
       DB       #11,#00,#11,#11,#11,#11,#00,#1F       ;........
       DB       #F1,#11,#10,#FF,#FF,#F1,#00,#1F       ;q....q..
       DB       #FF,#FF,#D0,#00,#0F,#F1,#11,#14       ;..P..q..
       DB       #44,#00,#00,#00,#0F,#21,#10,#00       ;D....!..
       DB       #00,#00,#00,#0A,#11,#11,#1F,#30       ;.......0
       DB       #00,#00,#00,#00,#10,#00,#11,#10       ;........
       DB       #00,#00,#0E,#F3,#10,#00,#1F,#FF       ;...s....
       DB       #EF,#FF,#01,#11,#10,#00,#11,#11       ;o.......
       DB       #11,#11,#11,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#01,#03       ;........
       DB       #00,#00,#11,#11,#11,#11,#11,#00       ;........
       DB       #00,#00,#10,#00,#00,#A4,#F1,#11       ;.....$q.
       DB       #00,#11,#1F,#F1,#00,#F4,#FF,#71       ;...q.t.q
       DB       #00,#10,#FF,#F1,#00,#11,#11,#11       ;...q....
       DB       #00,#10,#00,#D1,#FF,#51,#00,#00       ;...Q.Q..
       DB       #11,#10,#00,#00,#00,#D1,#00,#00       ;.....Q..
       DB       #1F,#F0,#00,#00,#E0,#01,#00,#00       ;.p..`...
       DB       #14,#4E,#00,#0F,#F0,#F1,#10,#00       ;.N..pq..
       DB       #1F,#FF,#00,#0F,#F0,#F2,#10,#00       ;....pr..
       DB       #11,#11,#11,#11,#11,#11,#10,#00       ;........
       DB       #08,#01,#01,#11,#10,#00,#00,#01       ;........
       DB       #11,#11,#01,#F3,#11,#11,#11,#11       ;...s....
       DB       #FF,#F1,#01,#00,#00,#AF,#71,#00       ;.q.../q.
       DB       #0F,#F1,#01,#00,#00,#00,#01,#10       ;.q......
       DB       #00,#01,#01,#1F,#D0,#8F,#FF,#F0       ;....P..p
       DB       #00,#01,#11,#A0,#00,#00,#00,#00       ;... ....
       DB       #B4,#31,#10,#00,#00,#0E,#00,#00       ;41......
       DB       #11,#11,#12,#00,#01,#11,#11,#11       ;........
       DB       #10,#00,#1F,#FF,#51,#00,#00,#00       ;....Q...
       DB       #00,#00,#11,#11,#11,#00,#00,#00       ;........
       DB       #00,#00,#01,#0E,#11,#11,#11,#11       ;........
       DB       #11,#11,#00,#00,#1C,#00,#0F,#FF       ;........
       DB       #1F,#F1,#11,#00,#10,#00,#01,#20       ;.q..... 
       DB       #10,#FF,#F1,#00,#10,#11,#11,#00       ;..q.....
       DB       #00,#00,#01,#00,#15,#10,#00,#00       ;........
       DB       #00,#00,#31,#00,#1A,#00,#00,#00       ;..1.....
       DB       #0B,#00,#F1,#00,#1F,#00,#00,#00       ;..q.....
       DB       #0F,#F1,#11,#11,#1F,#F0,#00,#00       ;.q...p..
       DB       #00,#08,#FF,#71,#11,#11,#11,#10       ;...q....
       DB       #00,#00,#00,#31,#00,#00,#00,#11       ;...1....
       DB       #11,#11,#11,#11,#02,#0C,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#01,#11       ;........
       DB       #11,#11,#11,#00,#00,#00,#01,#00       ;........
       DB       #00,#00,#F1,#11,#10,#00,#01,#00       ;..q.....
       DB       #FF,#00,#61,#DF,#10,#00,#01,#11       ;..a_....
       DB       #11,#00,#00,#0F,#10,#00,#00,#00       ;........
       DB       #01,#00,#00,#0C,#11,#10,#00,#00       ;........
       DB       #01,#04,#F0,#00,#12,#10,#00,#00       ;..p.....
       DB       #01,#F4,#71,#00,#F5,#10,#00,#00       ;.tq.u...
       DB       #01,#11,#11,#11,#11,#10,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#03,#05       ;........
       DB       #01,#11,#11,#11,#11,#00,#00,#00       ;........
       DB       #01,#2F,#F0,#35,#F1,#11,#11,#10       ;./p5q...
       DB       #01,#FF,#F0,#00,#01,#FF,#FF,#10       ;..p.....
       DB       #01,#11,#00,#0A,#B1,#0D,#FF,#10       ;....1...
       DB       #01,#F9,#00,#0F,#00,#00,#01,#10       ;.y......
       DB       #01,#F0,#00,#1F,#00,#00,#71,#00       ;.p....q.
       DB       #01,#F9,#00,#00,#00,#00,#01,#00       ;.y......
       DB       #01,#31,#00,#00,#0F,#F0,#F1,#00       ;.1...pq.
       DB       #01,#11,#90,#00,#01,#11,#11,#00       ;........
       DB       #00,#01,#11,#11,#11,#00,#00,#00       ;........
       DB       #02,#0D,#01,#00,#00,#DD,#00,#00       ;.....]..
       DB       #00,#00,#01,#00,#00,#00,#00,#00       ;........
       DB       #00,#81,#01,#90,#00,#00,#00,#00       ;........
       DB       #0F,#F1,#11,#00,#00,#0A,#10,#00       ;.q......
       DB       #F1,#11,#1F,#00,#00,#0F,#10,#00       ;q.......
       DB       #F3,#00,#1F,#00,#00,#0F,#10,#00       ;s.......
       DB       #00,#00,#1F,#B0,#00,#00,#00,#00       ;...0....
       DB       #00,#00,#11,#11,#20,#00,#00,#00       ;.... ...
       DB       #00,#00,#00,#01,#FF,#51,#00,#00       ;.....Q..
       DB       #00,#11,#00,#01,#11,#11,#00,#00       ;........
       DB       #3F,#F7,#02,#0E,#11,#11,#10,#00       ;?w......
       DB       #00,#00,#11,#11,#1F,#FF,#11,#11       ;........
       DB       #00,#00,#1F,#31,#1F,#FF,#FF,#01       ;...1....
       DB       #11,#11,#14,#41,#11,#10,#00,#02       ;...A....
       DB       #FF,#54,#1F,#F1,#00,#10,#00,#00       ;.T.q....
       DB       #00,#00,#0F,#F1,#00,#10,#00,#00       ;...q....
       DB       #00,#00,#0A,#11,#00,#10,#00,#00       ;........
       DB       #00,#00,#00,#10,#00,#1E,#00,#0F       ;........
       DB       #3F,#FE,#00,#10,#00,#17,#44,#B1       ;?~....D1
       DB       #11,#11,#11,#10,#00,#11,#11,#11       ;........
       DB       #00,#00,#00,#00,#01,#01,#90,#00       ;........
       DB       #00,#00,#00,#11,#11,#00,#11,#11       ;........
       DB       #11,#00,#00,#FF,#F1,#00,#10,#0F       ;....q...
       DB       #F1,#00,#00,#FF,#FF,#30,#10,#0F       ;q....0..
       DB       #F1,#00,#00,#00,#00,#00,#10,#08       ;q.......
       DB       #F1,#00,#00,#11,#11,#11,#10,#00       ;q.......
       DB       #00,#00,#00,#08,#34,#F1,#19,#00       ;....4q..
       DB       #00,#0F,#10,#00,#04,#F1,#11,#10       ;.....q..
       DB       #00,#04,#10,#09,#00,#01,#00,#10       ;........
       DB       #00,#0F,#FE,#00,#02,#F1,#00,#11       ;..~..q..
       DB       #11,#11,#11,#11,#11,#11,#02,#04       ;........
       DB       #01,#11,#10,#00,#11,#11,#00,#00       ;........
       DB       #01,#FF,#11,#11,#14,#71,#00,#00       ;.....q..
       DB       #01,#FF,#4F,#00,#04,#F1,#00,#00       ;..O..q..
       DB       #01,#00,#00,#00,#00,#81,#11,#10       ;........
       DB       #01,#90,#00,#00,#00,#01,#F2,#10       ;......r.
       DB       #01,#11,#16,#00,#00,#01,#FF,#10       ;........
       DB       #00,#00,#10,#00,#00,#00,#0A,#10       ;........
       DB       #00,#00,#1F,#00,#00,#E0,#00,#10       ;.....`..
       DB       #00,#00,#1F,#5F,#B1,#11,#11,#10       ;..._1...
       DB       #00,#00,#11,#11,#11,#00,#00,#00       ;........
       DB       #01,#02,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#17,#70,#00,#0D,#00,#00       ;...p....
       DB       #00,#81,#1F,#1D,#00,#00,#FF,#74       ;.......t
       DB       #00,#01,#15,#10,#00,#00,#11,#10       ;........
       DB       #00,#01,#10,#00,#00,#00,#00,#00       ;........
       DB       #00,#81,#10,#00,#00,#09,#00,#00       ;........
       DB       #00,#01,#10,#00,#90,#00,#00,#FE       ;.......~
       DB       #00,#01,#11,#11,#10,#00,#00,#FF       ;........
       DB       #11,#11,#12,#F5,#50,#08,#44,#FF       ;...uP.D.
       DB       #10,#00,#11,#11,#11,#11,#11,#11       ;........
       DB       #10,#00,#08,#0B,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#01,#11,#11,#11       ;........
       DB       #10,#00,#00,#00,#01,#3F,#00,#07       ;.....?..
       DB       #10,#00,#00,#00,#11,#1F,#00,#0F       ;........
       DB       #10,#00,#00,#00,#10,#00,#0A,#0F       ;........
       DB       #10,#00,#00,#00,#10,#00,#01,#0F       ;........
       DB       #11,#11,#11,#11,#1F,#FE,#01,#04       ;.....~..
       DB       #15,#43,#00,#01,#11,#11,#11,#00       ;.C......
       DB       #00,#00,#AF,#21,#00,#00,#01,#11       ;../!....
       DB       #00,#11,#11,#11,#00,#00,#0F,#FF       ;........
       DB       #E0,#10,#00,#00,#06,#01,#00,#11       ;`.......
       DB       #11,#11,#11,#11,#11,#00,#00,#1F       ;........
       DB       #F0,#B0,#FF,#F1,#01,#00,#00,#1F       ;p0.q....
       DB       #F0,#00,#00,#D0,#01,#11,#00,#1F       ;p..P....
       DB       #00,#00,#00,#00,#00,#A1,#00,#10       ;.....!..
       DB       #0F,#00,#00,#00,#00,#41,#11,#10       ;.....A..
       DB       #01,#10,#00,#00,#00,#41,#10,#00       ;.....A..
       DB       #00,#00,#00,#00,#00,#81,#1F,#F0       ;.......p
       DB       #E0,#1E,#00,#01,#11,#11,#1F,#F4       ;`......t
       DB       #F0,#12,#FF,#01,#00,#00,#11,#11       ;p.......
       DB       #11,#11,#11,#11,#00,#00,#01,#03       ;........
       DB       #01,#11,#11,#11,#11,#11,#10,#00       ;........
       DB       #01,#20,#F4,#F3,#1F,#FF,#10,#00       ;. ts....
       DB       #01,#F0,#F4,#0D,#10,#FF,#11,#11       ;.pt.....
       DB       #01,#F0,#00,#00,#10,#00,#00,#A1       ;.p.....!
       DB       #01,#00,#64,#44,#10,#00,#00,#D1       ;..dD...Q
       DB       #11,#B0,#00,#00,#00,#00,#00,#01       ;.0......
       DB       #10,#00,#00,#00,#7E,#03,#FF,#01       ;....~...
       DB       #19,#00,#00,#00,#11,#11,#11,#11       ;........
       DB       #10,#05,#F4,#FF,#10,#00,#00,#00       ;..t.....
       DB       #11,#11,#11,#11,#10,#00,#00,#00       ;........
       DB       #02,#0B,#01,#11,#11,#11,#11,#11       ;........
       DB       #11,#00,#01,#FF,#4F,#1F,#A0,#00       ;....O. .
       DB       #F1,#00,#01,#FF,#42,#1F,#F0,#00       ;q...B.p.
       DB       #F1,#00,#01,#51,#11,#1F,#F0,#00       ;q..Q..p.
       DB       #71,#00,#01,#0A,#00,#10,#00,#00       ;q.......
       DB       #01,#00,#01,#00,#00,#FF,#00,#01       ;........
       DB       #11,#10,#01,#00,#00,#00,#00,#00       ;........
       DB       #8F,#10,#01,#11,#0E,#00,#00,#B1       ;.......1
       DB       #FF,#10,#00,#01,#FF,#B0,#3F,#F1       ;.....0?q
       DB       #F3,#10,#00,#01,#11,#11,#11,#11       ;s.......
       DB       #11,#10,#03,#07,#11,#11,#11,#11       ;........
       DB       #11,#00,#11,#10,#1F,#D1,#00,#00       ;.....Q..
       DB       #B0,#00,#F2,#10,#1F,#00,#00,#00       ;0.r.....
       DB       #0A,#10,#FF,#10,#14,#00,#FF,#F1       ;.......q
       DB       #00,#10,#D0,#10,#14,#00,#DF,#F1       ;..P..._q
       DB       #00,#1F,#00,#00,#1F,#09,#00,#00       ;........
       DB       #00,#FF,#00,#00,#1F,#00,#00,#F7       ;.......w
       DB       #10,#05,#00,#00,#1F,#00,#00,#00       ;........
       DB       #00,#0D,#00,#01,#1F,#00,#00,#81       ;........
       DB       #0E,#00,#0E,#01,#11,#11,#11,#11       ;........
       DB       #11,#11,#11,#11,#03,#06,#00,#00       ;........
       DB       #00,#01,#11,#11,#11,#00,#01,#11       ;........
       DB       #11,#11,#FB,#0F,#21,#00,#01,#F0       ;..{.!..p
       DB       #AF,#71,#50,#0F,#F1,#00,#01,#F0       ;/qP.q..p
       DB       #0D,#81,#30,#03,#11,#11,#11,#10       ;..0.....
       DB       #00,#81,#00,#00,#0F,#F1,#10,#00       ;.....q..
       DB       #00,#00,#00,#00,#00,#A1,#10,#00       ;.....!..
       DB       #00,#00,#0A,#44,#5F,#F1,#1F,#4E       ;...D_q.N
       DB       #0F,#F1,#11,#11,#11,#11,#1F,#4F       ;.q.....O
       DB       #1F,#71,#00,#00,#00,#00,#11,#11       ;.q......
       DB       #11,#11,#00,#00,#00,#00,#08,#01       ;........
       DB       #01,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #01,#77,#FB,#0F,#FF,#14,#0F,#F1       ;.w{....q
       DB       #01,#11,#00,#0D,#FF,#14,#05,#F1       ;.......q
       DB       #01,#00,#00,#00,#00,#00,#05,#11       ;........
       DB       #01,#35,#4F,#00,#00,#00,#02,#10       ;.5O.....
       DB       #11,#1F,#4B,#00,#00,#00,#00,#10       ;..K.....
       DB       #10,#00,#00,#00,#03,#FF,#B0,#10       ;......0.
       DB       #10,#00,#00,#00,#01,#11,#11,#10       ;........
       DB       #17,#FF,#00,#00,#81,#00,#00,#00       ;........
       DB       #11,#11,#11,#11,#11,#00,#00,#00       ;........
       DB       #01,#09,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#11,#11,#11,#11,#11       ;........
       DB       #11,#00,#00,#1A,#00,#06,#F1,#00       ;......q.
       DB       #21,#00,#00,#10,#00,#00,#01,#00       ;!.......
       DB       #51,#00,#00,#11,#00,#00,#00,#08       ;Q.......
       DB       #F1,#00,#00,#10,#00,#0A,#19,#00       ;q.......
       DB       #01,#00,#00,#10,#E0,#0F,#FF,#01       ;....`...
       DB       #11,#00,#00,#1F,#F4,#00,#A0,#0F       ;....t. .
       DB       #71,#00,#00,#11,#11,#11,#11,#11       ;q.......
       DB       #11,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#07,#03,#11,#11,#11,#11       ;........
       DB       #60,#0F,#F1,#00,#1F,#F5,#4F,#F1       ;`.q..uOq
       DB       #00,#0F,#F1,#00,#12,#00,#0B,#F1       ;..q....q
       DB       #00,#00,#11,#11,#11,#00,#00,#00       ;........
       DB       #00,#00,#7F,#F1,#01,#00,#00,#00       ;...q....
       DB       #00,#00,#04,#41,#01,#90,#00,#00       ;...A....
       DB       #00,#00,#0A,#01,#01,#11,#90,#00       ;........
       DB       #00,#B1,#3F,#F1,#00,#01,#00,#00       ;.1?q....
       DB       #00,#11,#11,#11,#00,#01,#FF,#3F       ;.......?
       DB       #B0,#10,#00,#00,#00,#01,#11,#11       ;0.......
       DB       #11,#10,#00,#00,#01,#0C,#00,#00       ;........
       DB       #01,#11,#11,#11,#11,#10,#00,#11       ;........
       DB       #11,#F3,#10,#00,#FF,#10,#00,#1F       ;.s......
       DB       #F1,#44,#49,#00,#F1,#10,#00,#1D       ;qDI.q...
       DB       #F1,#00,#00,#00,#FD,#10,#00,#10       ;q...}...
       DB       #00,#00,#01,#10,#00,#10,#00,#10       ;........
       DB       #F3,#70,#25,#5A,#00,#10,#00,#10       ;sp%Z....
       DB       #08,#10,#00,#90,#00,#10,#00,#11       ;........
       DB       #11,#11,#11,#11,#00,#10,#00,#00       ;........
       DB       #00,#00,#00,#01,#7F,#10,#00,#00       ;........
       DB       #00,#00,#00,#01,#11,#10,#02,#04       ;........
       DB       #00,#00,#11,#1F,#F0,#00,#11,#00       ;....p...
       DB       #00,#00,#1F,#FF,#00,#A0,#01,#00       ;..... ..
       DB       #11,#11,#10,#00,#00,#13,#01,#00       ;........
       DB       #15,#FF,#20,#00,#00,#1F,#01,#11       ;.. .....
       DB       #1A,#00,#00,#00,#00,#00,#B1,#71       ;......1q
       DB       #1F,#FF,#00,#00,#00,#00,#00,#F1       ;.......q
       DB       #11,#1F,#FA,#00,#00,#00,#00,#41       ;..z....A
       DB       #00,#1F,#30,#0A,#00,#FF,#10,#41       ;..0....A
       DB       #00,#11,#11,#11,#11,#16,#1E,#F1       ;.......q
       DB       #00,#00,#00,#00,#00,#11,#11,#11       ;........
       DB       #01,#05,#00,#01,#11,#11,#11,#10       ;........
       DB       #00,#00,#00,#01,#FF,#FF,#FF,#11       ;........
       DB       #11,#11,#11,#11,#FB,#FF,#50,#08       ;....{.P.
       DB       #FF,#F1,#1F,#31,#00,#11,#F0,#00       ;.q.1..p.
       DB       #04,#41,#1F,#F1,#00,#01,#20,#00       ;.A.q.. .
       DB       #0F,#F1,#14,#00,#00,#00,#00,#01       ;.q......
       DB       #0F,#F1,#1F,#00,#00,#00,#00,#81       ;.q......
       DB       #11,#11,#10,#0A,#00,#10,#7F,#F1       ;.......q
       DB       #00,#00,#11,#11,#11,#1F,#FF,#31       ;.......1
       DB       #00,#00,#00,#00,#00,#11,#11,#11       ;........
       DB       #00,#00,#05,#0E,#11,#11,#11,#10       ;........
       DB       #01,#FF,#11,#11,#13,#FF,#F1,#00       ;......q.
       DB       #0B,#FF,#1F,#21,#1F,#FF,#5B,#00       ;...!..[.
       DB       #00,#FF,#14,#41,#11,#11,#00,#00       ;...A....
       DB       #00,#11,#10,#01,#1D,#10,#00,#00       ;........
       DB       #00,#1B,#44,#41,#10,#00,#00,#00       ;..DA....
       DB       #A0,#10,#00,#E1,#10,#00,#00,#80       ; ..a....
       DB       #00,#00,#00,#01,#14,#41,#00,#00       ;.....A..
       DB       #00,#00,#00,#81,#1F,#71,#11,#44       ;.....q.D
       DB       #44,#08,#3F,#F1,#11,#11,#00,#00       ;D.?q....
       DB       #01,#01,#11,#11,#02,#0B,#01,#11       ;........
       DB       #10,#00,#00,#11,#11,#11,#01,#0D       ;........
       DB       #11,#11,#00,#1F,#3F,#F1,#01,#00       ;....?q..
       DB       #0F,#31,#11,#10,#D0,#01,#11,#00       ;.1..P...
       DB       #0F,#F1,#00,#00,#00,#A1,#1F,#0A       ;.q...!..
       DB       #00,#F1,#90,#00,#0F,#F1,#1F,#50       ;.q...q.P
       DB       #00,#00,#08,#11,#01,#21,#11,#19       ;.....!..
       DB       #00,#00,#00,#7F,#01,#11,#1F,#FF       ;........
       DB       #4F,#11,#11,#11,#11,#00,#1F,#FF       ;O.......
       DB       #4F,#10,#00,#00,#00,#00,#11,#11       ;O.......
       DB       #11,#10,#00,#00,#00,#00,#08,#01       ;........
       DB       #00,#00,#11,#11,#11,#01,#10,#00       ;........
       DB       #11,#11,#1B,#4F,#F9,#00,#10,#00       ;...Oy...
       DB       #1F,#43,#00,#45,#FF,#00,#10,#00       ;.C.E....
       DB       #1F,#11,#00,#00,#11,#10,#11,#11       ;........
       DB       #1F,#4B,#00,#00,#00,#00,#00,#81       ;.K......
       DB       #10,#00,#00,#00,#90,#00,#00,#01       ;........
       DB       #19,#00,#00,#00,#00,#00,#01,#71       ;.......q
       DB       #11,#10,#01,#40,#02,#F0,#3F,#F1       ;...@.p?q
       DB       #00,#1F,#FF,#4E,#04,#4B,#11,#11       ;...N.K..
       DB       #00,#11,#11,#11,#11,#11,#10,#00       ;........
       DB       #02,#01,#00,#11,#11,#11,#11,#11       ;........
       DB       #11,#00,#00,#13,#F1,#7F,#1F,#45       ;....q..E
       DB       #51,#00,#00,#1F,#F1,#0F,#1F,#D0       ;Q...q..P
       DB       #21,#00,#00,#14,#01,#0D,#1F,#01       ;!.......
       DB       #11,#00,#00,#19,#00,#00,#00,#00       ;........
       DB       #01,#00,#00,#1A,#00,#00,#00,#00       ;........
       DB       #11,#00,#00,#10,#01,#E1,#01,#00       ;.....a..
       DB       #01,#00,#00,#10,#01,#F1,#01,#FE       ;.....q.~
       DB       #F1,#00,#00,#1F,#E1,#31,#BF,#F7       ;q...a1?w
       DB       #F1,#00,#00,#11,#11,#11,#11,#11       ;q.......
       DB       #11,#00,#08,#03,#11,#11,#11,#10       ;........
       DB       #01,#11,#11,#11,#10,#00,#00,#10       ;........
       DB       #01,#00,#00,#01,#10,#70,#00,#00       ;.....p..
       DB       #00,#00,#00,#01,#10,#90,#00,#00       ;........
       DB       #00,#00,#00,#01,#10,#00,#00,#00       ;........
       DB       #00,#00,#FF,#01,#11,#10,#00,#00       ;........
       DB       #90,#00,#F1,#01,#1F,#F0,#00,#00       ;..q..p..
       DB       #00,#00,#F0,#01,#15,#10,#00,#00       ;..p.....
       DB       #11,#00,#00,#01,#12,#10,#00,#10       ;........
       DB       #16,#C0,#00,#01,#11,#11,#11,#10       ;.@......
       DB       #11,#11,#11,#11,#06,#0C,#00,#00       ;........
       DB       #00,#01,#11,#11,#11,#11,#00,#11       ;........
       DB       #11,#11,#F1,#70,#00,#01,#00,#12       ;..qp....
       DB       #10,#01,#F1,#10,#00,#01,#00,#1F       ;..q.....
       DB       #10,#08,#FF,#10,#00,#C1,#00,#15       ;.....A..
       DB       #B0,#00,#01,#11,#B1,#11,#00,#10       ;0...1...
       DB       #00,#00,#01,#00,#00,#10,#11,#10       ;........
       DB       #00,#00,#01,#00,#00,#10,#13,#10       ;........
       DB       #00,#00,#00,#00,#08,#10,#1F,#40       ;.......@
       DB       #0E,#00,#81,#04,#43,#10,#11,#11       ;....C...
       DB       #11,#11,#11,#11,#11,#10,#01,#08       ;........
       DB       #01,#11,#11,#11,#10,#0F,#FF,#20       ;....... 
       DB       #01,#B1,#3F,#F5,#00,#00,#FF,#10       ;.1?u....
       DB       #01,#01,#00,#01,#10,#00,#11,#10       ;........
       DB       #01,#00,#00,#00,#00,#00,#08,#10       ;........
       DB       #01,#4F,#F7,#00,#00,#00,#0F,#10       ;.Ow.....
       DB       #01,#00,#11,#10,#00,#00,#0F,#10       ;........
       DB       #01,#F0,#00,#00,#00,#00,#0F,#F0       ;.p.....p
       DB       #01,#00,#00,#00,#00,#00,#08,#F0       ;.......p
       DB       #01,#FF,#F3,#10,#00,#00,#00,#10       ;..s.....
       DB       #01,#11,#11,#11,#1C,#00,#11,#10       ;........
       DB       #05,#0D,#00,#00,#11,#11,#11,#11       ;........
       DB       #11,#10,#11,#11,#10,#00,#0A,#F0       ;.......p
       DB       #DD,#10,#2F,#F5,#A0,#0F,#11,#F0       ;]./u ..p
       DB       #00,#11,#00,#00,#00,#FF,#F1,#A0       ;......q 
       DB       #00,#01,#1A,#00,#B0,#00,#00,#00       ;....0...
       DB       #14,#11,#1F,#00,#00,#00,#00,#11       ;........
       DB       #14,#41,#FF,#00,#00,#00,#0F,#7F       ;.A......
       DB       #F0,#41,#F0,#00,#00,#00,#0D,#00       ;pAp.....
       DB       #00,#A1,#00,#00,#FF,#FE,#00,#00       ;.!...~..
       DB       #00,#01,#0F,#FF,#F1,#11,#11,#11       ;....q...
       DB       #11,#11,#09,#01,#00,#00,#00,#00       ;........
       DB       #01,#0F,#FF,#10,#01,#11,#11,#11       ;........
       DB       #11,#00,#FF,#10,#01,#00,#0F,#54       ;.......T
       DB       #FB,#00,#00,#10,#01,#D0,#00,#00       ;{....P..
       DB       #00,#00,#00,#10,#01,#00,#01,#1B       ;........
       DB       #00,#00,#00,#10,#01,#07,#13,#F0       ;.......p
       DB       #00,#00,#04,#10,#01,#00,#1F,#FF       ;........
       DB       #00,#0B,#07,#10,#01,#00,#11,#09       ;........
       DB       #00,#00,#13,#10,#01,#C5,#21,#11       ;.....E!.
       DB       #11,#11,#11,#10,#01,#FF,#11,#00       ;........
       DB       #00,#00,#00,#00,#00,#0D,#11,#11       ;........
       DB       #11,#00,#00,#0F,#30,#00,#19,#00       ;....0...
       DB       #01,#A9,#00,#01,#11,#00,#10,#00       ;.)......
       DB       #07,#F0,#00,#00,#71,#00,#10,#00       ;.p..q...
       DB       #00,#00,#00,#EF,#F1,#00,#12,#00       ;...oq...
       DB       #00,#00,#00,#06,#31,#00,#55,#00       ;....1.U.
       DB       #01,#00,#00,#00,#01,#11,#50,#00       ;......P.
       DB       #01,#70,#0B,#00,#0F,#F1,#F0,#00       ;.p...qp.
       DB       #BF,#F0,#00,#00,#00,#F1,#A0,#00       ;?p...q .
       DB       #00,#F1,#00,#00,#00,#81,#00,#00       ;.q......
       DB       #0E,#11,#11,#11,#11,#11,#06,#0D       ;........
       DB       #00,#11,#11,#11,#11,#11,#11,#11       ;........
       DB       #00,#13,#FF,#01,#3F,#50,#0F,#F1       ;....?P.q
       DB       #00,#1F,#F0,#01,#0F,#F0,#00,#21       ;..p..p.!
       DB       #11,#10,#00,#81,#00,#00,#01,#11       ;........
       DB       #10,#00,#00,#00,#00,#00,#EA,#F1       ;......jq
       DB       #10,#00,#00,#00,#09,#00,#0F,#F1       ;.......q
       DB       #1F,#00,#10,#1A,#00,#00,#00,#71       ;.......q
       DB       #1F,#E4,#10,#10,#00,#0E,#81,#11       ;.d......
       DB       #1F,#F4,#1E,#FF,#F0,#00,#01,#00       ;.t..p...
       DB       #11,#11,#11,#11,#11,#11,#11,#00       ;........
       DB       #08,#01,#11,#11,#11,#11,#11,#16       ;........
       DB       #11,#11,#10,#01,#71,#00,#00,#10       ;....q...
       DB       #00,#01,#10,#00,#01,#00,#00,#10       ;........
       DB       #00,#01,#10,#00,#00,#00,#00,#00       ;........
       DB       #01,#11,#1F,#F0,#00,#00,#00,#00       ;...p....
       DB       #0F,#F1,#1F,#F0,#00,#00,#00,#00       ;.q.p....
       DB       #0F,#F1,#15,#00,#01,#00,#00,#10       ;.q......
       DB       #00,#F1,#15,#00,#01,#00,#00,#10       ;.q......
       DB       #00,#01,#12,#10,#01,#C0,#0C,#17       ;.....@..
       DB       #00,#01,#11,#10,#01,#11,#11,#11       ;........
       DB       #00,#01,#04,#0E,#01,#11,#10,#01       ;........
       DB       #11,#11,#11,#10,#01,#FF,#11,#11       ;........
       DB       #B0,#00,#08,#10,#01,#FD,#13,#FF       ;0....}..
       DB       #00,#00,#00,#10,#01,#00,#10,#00       ;........
       DB       #00,#00,#02,#10,#01,#00,#00,#00       ;........
       DB       #00,#00,#0F,#10,#01,#30,#7F,#FF       ;.....0..
       DB       #40,#01,#1F,#10,#01,#F0,#11,#D0       ;@....p.P
       DB       #00,#00,#5F,#10,#01,#F0,#00,#00       ;.._..p..
       DB       #00,#00,#08,#10,#01,#00,#00,#04       ;........
       DB       #4F,#FE,#11,#10,#01,#11,#11,#11       ;O~......
       DB       #11,#11,#10,#00,#01,#02,#01,#11       ;........
       DB       #11,#11,#11,#11,#11,#11,#01,#FF       ;........
       DB       #FF,#00,#10,#01,#6F,#01,#01,#11       ;....o...
       DB       #F9,#00,#00,#01,#1F,#01,#00,#01       ;y.......
       DB       #00,#00,#00,#00,#00,#01,#00,#01       ;........
       DB       #00,#00,#00,#00,#00,#81,#11,#11       ;........
       DB       #10,#00,#00,#00,#00,#11,#15,#55       ;.......U
       DB       #00,#00,#E0,#71,#0F,#71,#1F,#10       ;..`q.q..
       DB       #00,#00,#1F,#F1,#CF,#11,#12,#10       ;...qO...
       DB       #07,#FF,#11,#11,#11,#10,#11,#11       ;........
       DB       #11,#11,#10,#00,#00,#00,#01,#02       ;........
       DB       #00,#2F,#5F,#00,#00,#00,#00,#00       ;./_.....
       DB       #00,#11,#51,#11,#11,#11,#61,#00       ;..Q...a.
       DB       #00,#10,#00,#10,#01,#0F,#F1,#00       ;......q.
       DB       #00,#10,#00,#00,#01,#01,#11,#00       ;........
       DB       #00,#10,#00,#01,#01,#00,#71,#00       ;......q.
       DB       #00,#10,#E0,#A4,#44,#01,#11,#00       ;..`$D...
       DB       #00,#1F,#10,#FF,#00,#00,#01,#00       ;........
       DB       #00,#17,#10,#F1,#00,#40,#C1,#00       ;...q.@A.
       DB       #00,#11,#11,#11,#11,#FF,#11,#00       ;........
       DB       #00,#00,#00,#00,#00,#0F,#F0,#00       ;......p.
       DB       #09,#0C,#00,#01,#11,#11,#11,#10       ;........
       DB       #00,#00,#00,#01,#7F,#31,#7F,#11       ;.....1..
       DB       #11,#11,#11,#11,#7F,#11,#1F,#F1       ;.......q
       DB       #20,#01,#10,#40,#00,#00,#00,#00       ; ..@....
       DB       #00,#A1,#10,#00,#00,#00,#00,#00       ;.!......
       DB       #00,#01,#1E,#40,#00,#00,#00,#55       ;...@...U
       DB       #FE,#01,#1F,#19,#00,#00,#00,#01       ;~.......
       DB       #11,#11,#11,#13,#F4,#50,#00,#00       ;....tP..
       DB       #01,#00,#00,#11,#11,#1B,#0E,#00       ;........
       DB       #81,#00,#00,#00,#00,#11,#11,#11       ;........
       DB       #11,#00,#06,#01,#11,#11,#11,#10       ;........
       DB       #00,#D0,#00,#00,#12,#00,#00,#11       ;.P......
       DB       #1F,#44,#00,#00,#1F,#00,#00,#6F       ;.D.....o
       DB       #10,#00,#00,#00,#1F,#D0,#00,#00       ;.....P..
       DB       #D0,#00,#00,#00,#1F,#00,#00,#00       ;P.......
       DB       #00,#00,#00,#08,#11,#00,#00,#00       ;........
       DB       #00,#00,#00,#A1,#10,#00,#00,#00       ;...!....
       DB       #00,#00,#00,#01,#FA,#00,#00,#00       ;....z...
       DB       #00,#00,#00,#01,#F0,#00,#00,#1B       ;....p...
       DB       #0B,#FF,#F1,#11,#FF,#0E,#FF,#11       ;..q.....
       DB       #11,#11,#11,#00,#08,#0C,#00,#11       ;........
       DB       #11,#11,#2F,#51,#00,#00,#00,#1F       ;../Q....
       DB       #0D,#01,#11,#F1,#11,#11,#00,#1F       ;...q....
       DB       #00,#00,#0D,#50,#FF,#F1,#11,#14       ;...P.q..
       DB       #00,#00,#00,#00,#11,#71,#10,#FF       ;.....q..
       DB       #00,#08,#00,#00,#00,#F1,#10,#01       ;.....q..
       DB       #00,#00,#00,#A0,#00,#01,#10,#01       ;... ....
       DB       #10,#00,#0F,#F4,#07,#11,#10,#06       ;...t....
       DB       #30,#01,#11,#1E,#03,#10,#1B,#00       ;0.......
       DB       #00,#A1,#00,#11,#11,#10,#11,#11       ;.!......
       DB       #11,#11,#00,#00,#00,#00,#01,#03       ;........
       DB       #00,#F1,#F0,#0F,#F0,#00,#0D,#00       ;.qp.p...
       DB       #1F,#FF,#00,#00,#00,#00,#00,#D8       ;.......X
       DB       #1F,#FF,#F0,#E0,#D0,#00,#00,#00       ;..p`P...
       DB       #1F,#D0,#00,#00,#00,#00,#E0,#00       ;.P....`.
       DB       #1F,#90,#00,#00,#00,#00,#00,#41       ;.......A
       DB       #00,#00,#0E,#D0,#00,#00,#00,#52       ;...P...R
       DB       #00,#0D,#11,#19,#40,#00,#00,#01       ;....@...
       DB       #10,#00,#03,#10,#4E,#00,#00,#87       ;....N...
       DB       #1A,#00,#0F,#11,#11,#00,#00,#0F       ;........
       DB       #11,#11,#0F,#13,#FF,#A0,#F0,#FF       ;..... p.
       DB       #00,#08,#01,#11,#11,#11,#11,#11       ;........
       DB       #11,#10,#01,#00,#00,#00,#59,#00       ;......Y.
       DB       #0F,#20,#01,#71,#ED,#00,#00,#0E       ;. .qm...
       DB       #00,#10,#01,#00,#00,#00,#08,#00       ;........
       DB       #00,#10,#01,#A0,#00,#00,#4F,#00       ;... ..O.
       DB       #0F,#10,#01,#90,#0D,#00,#E0,#00       ;......`.
       DB       #0B,#10,#01,#00,#04,#00,#00,#00       ;........
       DB       #00,#10,#01,#90,#04,#00,#00,#0A       ;........
       DB       #06,#10,#01,#FF,#04,#0E,#00,#00       ;........
       DB       #00,#10,#01,#F1,#11,#11,#11,#11       ;...q....
       DB       #11,#10,#09,#02,#11,#11,#00,#00       ;........
       DB       #00,#00,#00,#00,#1F,#F1,#00,#00       ;.....q..
       DB       #00,#00,#00,#00,#10,#F1,#11,#11       ;.....q..
       DB       #11,#11,#10,#00,#10,#00,#00,#C1       ;.......A
       DB       #00,#0C,#11,#71,#10,#00,#00,#01       ;...q....
       DB       #10,#00,#1F,#71,#11,#10,#01,#00       ;...q....
       DB       #14,#41,#1F,#61,#10,#00,#01,#00       ;.A.a....
       DB       #00,#00,#05,#11,#10,#0F,#71,#00       ;......q.
       DB       #00,#E0,#00,#01,#11,#11,#11,#11       ;.`......
       DB       #1F,#F1,#11,#11,#00,#00,#00,#02       ;.q......
       DB       #55,#11,#00,#00,#01,#02,#21,#00       ;U.....!.
       DB       #75,#D4,#71,#D0,#00,#F1,#51,#90       ;uTqP.qQ.
       DB       #00,#00,#01,#00,#00,#F1,#5F,#FA       ;.....q_z
       DB       #00,#0F,#F1,#00,#00,#D1,#FF,#F0       ;..q..Q.p
       DB       #00,#00,#B1,#00,#00,#01,#11,#F0       ;..1....p
       DB       #00,#00,#01,#00,#00,#81,#00,#00       ;........
       DB       #00,#00,#0D,#00,#00,#01,#17,#7E       ;.......~
       DB       #00,#00,#00,#00,#00,#01,#11,#5F       ;......._
       DB       #00,#00,#00,#00,#01,#01,#1F,#A0       ;....... 
       DB       #00,#00,#00,#00,#61,#01,#10,#0A       ;....a...
       DB       #00,#B0,#00,#0F,#FF,#01,#00,#0E       ;.0......
       DB       #00,#15,#F5,#FF,#21,#77,#B0,#10       ;..u.!w0.
       DB       #00,#1F,#11,#11,#11,#11,#00,#10       ;........
       DB       #00,#10,#00,#6F,#1F,#F0,#08,#10       ;...o.p..
       DB       #00,#10,#00,#FF,#10,#31,#11,#10       ;.....1..
       DB       #01,#10,#00,#40,#00,#00,#08,#10       ;...@....
       DB       #01,#00,#00,#40,#00,#00,#01,#10       ;...@....
       DB       #01,#10,#00,#40,#00,#00,#0F,#10       ;...@....
       DB       #01,#35,#71,#11,#11,#1F,#01,#10       ;.5q.....
       DB       #01,#11,#11,#00,#00,#1F,#00,#10       ;........
       DB       #00,#00,#00,#00,#00,#1F,#FC,#10       ;......|.
       DB       #07,#0B,#11,#11,#11,#11,#11,#11       ;........
       DB       #11,#11,#25,#FF,#10
       db #00
       db #01
       db #00       ;..%.....
       DB       #00,#01,#10,#00,#10,#00,#01,#00       ;........
       DB       #00,#01,#10,#00,#00,#00,#07,#00       ;........
       DB       #00,#01,#10,#00,#00,#00,#00,#00       ;........
       DB       #0E,#01,#10,#00,#40,#00,#FF,#00       ;....@...
       DB       #0F,#11,#1A,#00,#40,#00,#01,#00       ;....@...
       DB       #0F,#F1,#1F,#60,#40,#00,#00,#00       ;.q.`@...
       DB       #08,#F1,#11,#11,#10,#00,#00,#00       ;.q......
       DB       #01,#11,#00,#00,#1C,#00,#01,#11       ;........
       DB       #11,#00,#06,#0E,#11,#11,#11,#00       ;........
       DB       #11,#11,#01,#11,#14,#44,#41,#11       ;.....DA.
       DB       #1F,#41,#01,#21,#14,#14,#44,#08       ;.A.!..D.
       DB       #FF,#41,#11,#51,#13,#F4,#04,#04       ;.A.Q.t..
       DB       #0D,#00,#00,#F1,#11,#10,#00,#00       ;...q....
       DB       #00,#00,#0A,#F1,#00,#10,#00,#00       ;...q....
       DB       #00,#00,#0F,#F1,#00,#10,#0A,#FF       ;...q....
       DB       #F0,#E0,#01,#11,#00,#FF,#00,#F1       ;p`.....q
       DB       #11,#11,#11,#00,#00,#1F,#00,#01       ;........
       DB       #7F,#00,#00,#00,#00,#11,#11,#11       ;........
       DB       #FF,#30,#00,#00,#07,#02,#2F,#F5       ;.0..../u
       DB       #FF,#1F,#FF,#FF,#1F,#F1,#1F,#1F       ;.....q..
       DB       #F1,#5F,#16,#51,#F7,#F1,#11,#5F       ;q_.Qwq._
       DB       #F7,#F1,#F5,#F1,#53,#F1,#17,#41       ;wquqSq.A
       DB       #15,#1F,#11,#FF,#F1,#41,#11,#54       ;....qA.T
       DB       #54,#57,#1F,#1F,#F1,#51,#1F,#41       ;TW..qQ.A
       DB       #14,#1F,#54,#F4,#45,#71,#1F,#13       ;..TtEq..
       DB       #15,#FF,#15,#15,#14,#41,#1F,#44       ;.....A.D
       DB       #14,#F4,#57,#54,#41,#51,#1F,#F1       ;.tWTAQ.q
       DB       #F5,#15,#14,#14,#45,#41,#17,#57       ;u...EA.W
       DB       #FF,#14,#64,#57,#41,#7F,#09,#0F       ;..dWA...
       DB       #10,#4F,#00,#00,#10,#D0,#00,#08       ;.O...P..
       DB       #10,#44,#00,#80,#50,#00,#10,#81       ;.D..P...
       DB       #1F,#00,#01,#10,#D0,#00,#90,#31       ;....P..1
       DB       #10,#81,#70,#0A,#01,#00,#00,#01       ;..p.....
       DB       #1A,#00,#00,#40,#00,#00,#80,#71       ;...@...q
       DB       #11,#11,#14,#41,#41,#10,#10,#11       ;...AA...
       DB       #10,#00,#10,#60,#1D,#1E,#10,#31       ;...`...1
       DB       #20,#00,#10,#E1,#10,#D1,#10,#81       ; ..a.Q..
       DB       #1C,#00,#D1,#11,#0A,#00,#00,#01       ;..Q.....
       DB       #14,#E0,#05,#00,#00,#0A,#0E,#01       ;.`......
       DB       #00,#03,#00,#00,#00,#00,#0A,#08       ;........
       DB       #00,#01,#51,#14,#44,#00,#91,#90       ;..Q.D...
       DB       #02,#01,#00,#14,#F4,#04,#54,#00       ;....t.T.
       DB       #05,#01,#09,#0F,#34,#44,#14,#00       ;....4D..
       DB       #05,#41,#90,#00,#00,#00,#14,#05       ;.A......
       DB       #44,#41,#00,#00,#74,#01,#10,#44       ;DA..t..D
       DB       #11,#11,#00,#0E,#09,#01,#70,#11       ;......p.
       DB       #14,#41,#E0,#09,#00,#00,#0E,#00       ;.A`.....
       DB       #04,#41,#00,#00,#00,#1E,#00,#00       ;.A......
       DB       #44,#11,#9E,#00,#00,#54,#A0,#03       ;D....T .
       DB       #F1,#10,#02,#04,#00,#00,#12,#00       ;q.......
       DB       #DD,#00,#08,#01,#00,#00,#05,#00       ;].......
       DB       #00,#05,#08,#01,#00,#00,#04,#81       ;........
       DB       #01,#00,#00,#01,#00,#00,#B0,#00       ;......0.
       DB       #00,#E0,#0D,#A1,#D4,#44,#15,#0F       ;.`.!TD..
       DB       #00,#40,#00,#01,#0D,#00,#00,#00       ;.@......
       DB       #08,#00,#00,#51,#08,#00,#00,#11       ;...Q....
       DB       #01,#00,#01,#31,#60,#44,#00,#0D       ;...1`D..
       DB       #07,#00,#00,#81,#14,#40,#00,#00       ;.....@..
       DB       #0D,#00,#E8,#01,#F4,#0D,#DD,#D0       ;..h.t.]P
       DB       #00,#3E,#00,#00,#09,#00,#00,#00       ;.>......
       DB       #00,#01,#09,#00,#01,#11,#4F,#F0       ;......Op
       DB       #F1,#11,#00,#00,#12,#51,#C8,#00       ;q....QH.
       DB       #00,#10,#01,#10,#11,#F1,#0F,#0E       ;.....q..
       DB       #07,#00,#B0,#10,#0F,#01,#01,#F4       ;..0....t
       DB       #0D,#00,#00,#00,#08,#01,#11,#F0       ;.......p
       DB       #00,#00,#00,#30,#F0,#01,#F9,#00       ;...0p.y.
       DB       #00,#00,#01,#05,#F0,#41,#FF,#F0       ;....pA.p
       DB       #04,#37,#11,#00,#0B,#E1,#F0,#00       ;.7...ap.
       DB       #B0,#00,#19,#E0,#40,#01,#11,#11       ;0..`@...
       DB       #01,#11,#11,#11,#11,#11,#01,#01       ;........
       
;
;L_B6E6        
       DB       #3E,#01,#CD,#81,#B7,#3E,#05,#CD       ;>.M.7>.M
       DB       #81,#B7,#3E,#07,#CD,#81,#B7       ;.7>.M.7
 
        ;display $-levels
;
        ;display $
SlowClearScreen
	LD	IX,L_B77B
	XOR	A
	LD	(IX+#00),A
.l0	CALL	L_B70F
	LD	A,(IX+#00)
	CP	#25
	JP	Z,ClearScreen
	HALT
	INC	A
	LD	(IX+#00),A
	JR	.l0
;
L_B70F	LD	A,(IX+#00)
	LD	(IX+#01),A
	LD	B,#07
.l0	PUSH	BC
	CALL	L_B726
	LD	A,(IX+#01)
	DEC	A
	LD	(IX+#01),A
	POP	BC
	DJNZ	.l0
	RET
;
L_B726	LD	A,(IX+#01)
	OR	A
	RET	M
	CP	#20
	RET	NC
	LD	A,B
	CP	#01
	JR	Z,L_B75B
	LD	C,A
	LD	B,#00
	LD	HL,L_B792
	ADD	HL,BC
	LD	A,(HL)
	LD	(L_B74D),A
	LD	A,(IX+#01)
	LD	L,A
	LD	H,#40
	LD	B,#C0
	LD	A,R
	AND	#1F
	LD	D,A
L_B74B	LD	A,(DE)
	LD	C,#00
L_B74D       EQU       $-1
	OR	C
	LD	C,A
	LD	A,(HL)
	AND	C
	LD	(HL),A
	INC	H
	INC	DE
	CALL	DownHL2
	DJNZ	L_B74B
	RET
;
L_B75B	LD	A,(IX+#01)
	LD	L,A
	LD	H,#58
	LD	B,#18
	LD	DE,#0020
	LD	C,#00
.l0	LD	(HL),C
	ADD	HL,DE
	DJNZ	.l0
	RET
;
DownHL2
	LD	A,H
	AND	#07
	RET	NZ
	LD	A,L
	ADD	A,#20
	LD	L,A
	RET	C
	LD	A,H
	SUB	#08
	LD	H,A
	RET
;
L_B77B       DB       #00,#00,#00,#00,#00,#00
;
L_B781	LD	HL,#5800
	PUSH	HL
	POP	DE
	INC	E
	LD	BC,#02FF
	LD	(HL),A
	LDIR
	HALT
	HALT
	HALT
	HALT
	HALT
	RET
;
L_B792=$-1
       DB       #55       ; .@.@.@.@
       DB       #AA       ; @.@.@.@.
       DB       #11       ; ...@...@
       DB       #41       ; .@.....@
       DB       #88       ; @...@...
       DB       #44       ; .@...@..
       DB       #22       ; ..@...@.
;
ClearScreen
	LD	HL,#4000
	PUSH	HL
	POP	DE
	INC	E
	LD	BC,#17FF
	LD	(HL),L
	LDIR
	RET
;
       if EGA == 0
ClearTile_DExy
;E=y
;D=x (width 24 if not multiple of 8)
	PUSH	BC
	PUSH	DE
	LD	BC,ScreenTable
	LD	L,E
	LD	H,#00
	ADD	HL,HL
	ADD	HL,BC
	PUSH	HL
	POP	IX
	LD	E,D
	SRL	E
	SRL	E
	SRL	E
	LD	A,D
	AND	#07
	LD	(L_B7D4),A
	LD	BC,#1000
L_B7C4	LD	A,(IX+#00)
	LD	H,(IX+#01)
	INC	IX
	INC	IX
	OR	E
	LD	L,A
	LD	(HL),C ;0
	INC	L
	LD	(HL),C ;0
	LD	A,#00
L_B7D4=$-1
	OR	A
	JR	Z,L_B7DA
	INC	L
	LD	(HL),C ;0
L_B7DA	DJNZ	L_B7C4
	POP	DE
	POP	BC
	RET
       endif
        
;
L_B7DF	PUSH	DE
	LD	HL,L_B7F3
	LD	A,#08
	CP	B
	JP	Z,L_B7EC
	LD	HL,#0000
L_B7EA=$-2
L_B7EC	LD	A,(HL)
	INC	HL
	LD	(L_B7EA),HL
	POP	DE
	RET
;
L_B7F3       DB       #04,#05,#03,#04,#05,#03,#04,#03
       DB       #00,#01,#02,#00,#01,#02,#00
;
       if 1==0
GenerateScreenTable
	LD	IX,ScreenTable
	LD	HL,#4000
	LD	B,#C0
.l0	LD	(IX+#00),L
	LD	(IX+#01),H
	INC	IX
	INC	IX
	INC	H
	CALL	DownHL
	DJNZ	.l0
	RET
       endif
;
ScreenTable
       DW       #4000
       DW       #4100
       DW       #4200
       DW       #4300
       DW       #4400
       DW       #4500
       DW       #4600
       DW       #4700
       DW       #4020
       DW       #4120
       DW       #4220
       DW       #4320
       DW       #4420
       DW       #4520
       DW       #4620
       DW       #4720
       DW       #4040
       DW       #4140
       DW       #4240
       DW       #4340
       DW       #4440
       DW       #4540
       DW       #4640
       DW       #4740
       DW       #4060
       DW       #4160
       DW       #4260
       DW       #4360
       DW       #4460
       DW       #4560
       DW       #4660
       DW       #4760
       DW       #4080
       DW       #4180
       DW       #4280
       DW       #4380
       DW       #4480
       DW       #4580
       DW       #4680
       DW       #4780
       DW       #40A0
       DW       #41A0
       DW       #42A0
       DW       #43A0
       DW       #44A0
       DW       #45A0
       DW       #46A0
       DW       #47A0
       DW       #40C0
       DW       #41C0
       DW       #42C0
       DW       #43C0
       DW       #44C0
       DW       #45C0
       DW       #46C0
       DW       #47C0
       DW       #40E0
       DW       #41E0
       DW       #42E0
       DW       #43E0
       DW       #44E0
       DW       #45E0
       DW       #46E0
       DW       #47E0
       DW       #4800
       DW       #4900
       DW       #4A00
       DW       #4B00
       DW       #4C00
       DW       #4D00
       DW       #4E00
       DW       #4F00
       DW       #4820
       DW       #4920
       DW       #4A20
       DW       #4B20
       DW       #4C20
       DW       #4D20
       DW       #4E20
       DW       #4F20
       DW       #4840
       DW       #4940
       DW       #4A40
       DW       #4B40
       DW       #4C40
       DW       #4D40
       DW       #4E40
       DW       #4F40
       DW       #4860
       DW       #4960
       DW       #4A60
       DW       #4B60
       DW       #4C60
       DW       #4D60
       DW       #4E60
       DW       #4F60
       DW       #4880
       DW       #4980
       DW       #4A80
       DW       #4B80
       DW       #4C80
       DW       #4D80
       DW       #4E80
       DW       #4F80
       DW       #48A0
       DW       #49A0
       DW       #4AA0
       DW       #4BA0
       DW       #4CA0
       DW       #4DA0
       DW       #4EA0
       DW       #4FA0
       DW       #48C0
       DW       #49C0
       DW       #4AC0
       DW       #4BC0
       DW       #4CC0
       DW       #4DC0
       DW       #4EC0
       DW       #4FC0
       DW       #48E0
       DW       #49E0
       DW       #4AE0
       DW       #4BE0
       DW       #4CE0
       DW       #4DE0
       DW       #4EE0
       DW       #4FE0
       DW       #5000
       DW       #5100
       DW       #5200
       DW       #5300
       DW       #5400
       DW       #5500
       DW       #5600
       DW       #5700
       DW       #5020
       DW       #5120
       DW       #5220
       DW       #5320
       DW       #5420
       DW       #5520
       DW       #5620
       DW       #5720
       DW       #5040
       DW       #5140
       DW       #5240
       DW       #5340
       DW       #5440
       DW       #5540
       DW       #5640
       DW       #5740
       DW       #5060
       DW       #5160
       DW       #5260
       DW       #5360
       DW       #5460
       DW       #5560
       DW       #5660
       DW       #5760
       DW       #5080
       DW       #5180
       DW       #5280
       DW       #5380
       DW       #5480
       DW       #5580
       DW       #5680
       DW       #5780
       DW       #50A0
       DW       #51A0
       DW       #52A0
       DW       #53A0
       DW       #54A0
       DW       #55A0
       DW       #56A0
       DW       #57A0
       DW       #50C0
       DW       #51C0
       DW       #52C0
       DW       #53C0
       DW       #54C0
       DW       #55C0
       DW       #56C0
       DW       #57C0
       DW       #50E0
       DW       #51E0
       DW       #52E0
       DW       #53E0
       DW       #54E0
       DW       #55E0
       DW       #56E0
       DW       #57E0
;
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       
;
       if EGA == 0
DrawSprite_Akeep_DExy
	LD	(cursprite),A
DrawSprite_A_DExy
;A=sprnum
;DE=xy
	PUSH	BC
	PUSH	DE
	PUSH	DE
	LD	H,#00
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	L,A
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	LD	DE,sprites
	ADD	HL,DE
	POP	DE
	LD	(L_BA29),SP
	DI
	LD	SP,HL
	LD	BC,ScreenTable
	LD	H,#00
	LD	L,E
	ADD	HL,HL
	ADD	HL,BC
	LD	(L_B9D3),HL
	LD	IX,#0000
L_B9D3=$-2
	LD	A,D
	SRL	A
	SRL	A
	SRL	A
	LD	(L_BA12),A
	LD	A,D
	AND	#07
	LD	(L_B9EF),A
	LD	B,#10
L_B9E7	EXX
	POP	DE ;spr
	POP	BC ;mask
	LD	H,#00
	LD	L,#FF
	LD	A,#00
L_B9EF=$-1
	OR	A
	JR	Z,L_BA04
L_B9F3	SCF
	RR	C
	RR	B
	RR	L
	AND	A
	RR	E
	RR	D
	RR	H
	DEC	A
	JR	NZ,L_B9F3
L_BA04	LD	(L_BA20),HL
	LD	A,(IX+#00)
	INC	IX
	LD	H,(IX+#00)
	INC	IX
	OR	#00
L_BA12=$-1
	LD	L,A
	LD	A,(HL)
	AND	C
	OR	E
	LD	(HL),A
	INC	L
	LD	A,(HL)
	AND	B
	OR	D
	LD	(HL),A
	INC	L
	LD	A,(HL)
	LD	DE,#0000
L_BA20=$-2
	AND	E
	OR	D
	LD	(HL),A
	EXX
	DJNZ	L_B9E7
	LD	SP,#0000
L_BA29=$-2
	POP	DE
	POP	BC
	EI
	RET
       endif
;
       ;DB       #C9       ;I
;
DownDE
	LD	A,D
	AND	#07
	RET	NZ
	LD	A,E
	ADD	A,#20
	LD	E,A
	RET	C
	LD	A,D
	SUB	#08
	LD	D,A
	RET
;
DownHL
	LD	A,H
	AND	#07
	RET	NZ
	LD	A,L
	ADD	A,#20
	LD	L,A
	RET	C
	LD	A,H
	SUB	#08
	LD	H,A
	RET

        if EGA == 0
;
GetBuf24x16_DExy
;e=y
;d=x
	PUSH	DE
	PUSH	BC
	PUSH	DE
	LD	HL,ScreenTable
	LD	A,E
	ADD	A,A
	JR	NC,L_BA57
	INC	H
L_BA57	ADD	A,L
	LD	L,A
	ADC	A,H
	SUB	L
	LD	H,A
	LD	A,(HL)
	INC	HL
	LD	H,(HL)
	LD	L,A
	POP	DE
	LD	A,D
	SRL	A
	SRL	A
	SRL	A
	OR	L
	LD	L,A
	LD	DE,ReBuf24x16_DExy
	LD	A,#10
L_BA6F	EX	AF,AF' ;'
	LDI
	LDI
	LDI
	DEC	HL
	DEC	HL
	DEC	L
	INC	H
	CALL	DownHL
	EX	AF,AF' ;'
	DEC	A
	JP	NZ,L_BA6F
	POP	BC
	POP	DE
	RET
        
;
ReBuf24x16_DExy
;e=y
;d=x (width 16 if multiple of 8)
	CALL	L_BBE0 ;ret
	PUSH	DE
	PUSH	BC
	PUSH	DE
	LD	HL,ScreenTable
	LD	A,E
	ADD	A,A
	JR	NC,L_BA93
	INC	H
L_BA93	ADD	A,L
	LD	L,A
	ADC	A,H
	SUB	L
	LD	H,A
	LD	A,(HL)
	INC	HL
	LD	H,(HL)
	LD	L,A
	POP	DE
	LD	A,D
	SRL	A
	SRL	A
	SRL	A
	OR	L
	LD	L,A
	LD	A,D
	AND	#07
	LD	(L_BAB8),A
	LD	DE,ReBuf24x16_DExy
	EX	DE,HL
	LD	A,#10
L_BAB2	EX	AF,AF' ;'
	LDI
	LDI
	LD	A,#00
L_BAB8=$-1
	OR	A
	INC	HL
	JP	Z,L_BAC2
	DEC	HL
	LDI
	DEC	DE
L_BAC2	DEC	DE
	DEC	E
	INC	D
	CALL	DownDE
	EX	AF,AF' ;'
	DEC	A
	JP	NZ,L_BAB2
	POP	BC
	POP	DE
	RET
        
        endif
;
       if EGA == 0
GetTileToHL_DEXY
	PUSH	HL
	CALL	XYDEToScr
	POP	DE
	LD	B,#10
	LD	C,#FF
L_BAD9	LDI
	LDI
	DEC	HL
	DEC	HL
	INC	H
	CALL	DownHL
	DJNZ	L_BAD9
	RET
       endif
;
       if EGA == 0
buf24x16
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00
gettilebuf2
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00      
ReBuf24x16_DExy
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00
       endif
;
       if EGA == 0
DrawSprite16x16_HL_DExy
;hl=gfx
;e=y
;d=x (pixel perfect!)
	LD	(L_BBA0),HL
	PUSH	BC
	PUSH	DE
	LD	BC,ScreenTable
	LD	H,#00
	LD	L,E
	ADD	HL,HL
	ADD	HL,BC
	PUSH	HL
	POP	IX
	LD	A,D
	SRL	A
	SRL	A
	SRL	A
	LD	(L_BBC8),A
	LD	A,D ;x
	AND	#07
	LD	(L_BBB3),A
	LD	(L_BBD5),A
	LD	HL,#0000
L_BBA0=$-2
	EXX
	LD	B,#10
L_BBA5	EXX
	LD	E,(HL)
	INC	HL
	LD	D,(HL)
	INC	HL
	LD	(L_BBB0),DE
	EXX
	LD	DE,#0000
L_BBB0=$-2
	LD	A,#00
L_BBB3=$-1
	OR	A
	JR	Z,L_BBC4
	LD	C,#00
L_BBB9	AND	A
	RR	E
	RR	D
	RR	C
	DEC	A
	JP	NZ,L_BBB9
L_BBC4	LD	A,(IX+#00)
	OR	#00
L_BBC8=$-1
	LD	H,(IX+#01)
	INC	IX
	INC	IX
	LD	L,A
	LD	(HL),E
	INC	L
	LD	(HL),D
	LD	A,#00
L_BBD5=$-1
	OR	A
	JR	Z,L_BBDB
	INC	L
	LD	(HL),C
L_BBDB	DJNZ	L_BBA5
	POP	DE
	POP	BC
	RET
       endif
;
L_BBE0	RET
;
       DB       #D5,#E5,#A7,#11,#E6,#BA,#ED,#52       ;Ue'.f:mR
       DB       #E1,#D1,#7C,#B5,#C0,#E5,#D5,#C5       ;aQ|5@eUE
       DB       #CD,#FF,#D0,#C1,#D1,#E1,#C9,#21       ;M.PAQaI!
       DB       #00,#58,#DD,#21,#3F,#58,#11,#40       ;.X]!?X.@
       DB       #00,#FB,#06,#20,#C5,#E5,#DD,#E5       ;.{. Ee]e
       DB       #06,#0C,#36,#00,#DD,#36,#00,#00       ;..6.]6..
       DB       #DD,#36,#FF,#1B,#23,#36,#1B,#2B       ;]6..#6.+
       DB       #19,#DD,#19,#10,#ED,#DD,#E1,#DD       ;.]..m]a]
       DB       #2B,#E1,#23,#76,#C1,#10,#DD,#21       ;+a#vA.]!
       DB       #00,#40,#11,#01,#40,#01,#FF,#1A       ;.@..@...
       DB       #75,#ED,#B0,#C9       ;um0I
;
        if EGA == 0
Clear2Bytes_ADyx
;A=y
;D=x
	PUSH	BC
	LD	H,#00
	LD	L,A
	ADD	HL,HL
	LD	BC,ScreenTable
	ADD	HL,BC
	LD	A,(HL)
	INC	HL
	LD	H,(HL)
	SRL	D
	SRL	D
	SRL	D
	OR	D
	LD	L,A
	LD	(HL),#00
	INC	L
	LD	(HL),#00
	POP	BC
	RET
        endif
;
        if EGA == 0
DrawTile_A_X2Y2DE
       PUSH	AF
	BIT	1,(IY+#00)
	JR	NZ,L_BC5C
	AND	A
	RL	D
	RL	E
L_BC5C	PUSH	DE
	LD	H,#00
	LD	L,A
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	LD	DE,tilegfxbw
	ADD	HL,DE
	POP	DE
	PUSH	HL
	CALL	XYDEToScr
	POP	DE
	EX	DE,HL
       POP	AF
       PUSH	AF
	PUSH	DE
	LD	B,#10
L_BC75	LD	A,(HL)
	LD	(DE),A
	INC	HL
	INC	E
	LD	A,(HL)
	LD	(DE),A
	INC	HL
	DEC	E
	INC	D
	LD	A,D
	AND	#07
	JR	NZ,L_BC8D
	LD	A,E
	ADD	A,#20
	LD	E,A
	JR	C,L_BC8D
	LD	A,D
	SUB	#08
	LD	D,A
L_BC8D	DJNZ	L_BC75
	POP	HL
	LD	A,H
	RRA
	RRA
	RRA
	AND	#03
	OR	#58
	LD	H,A
       POP	AF
	BIT	1,(IY+#00)
	RET	NZ
	PUSH	HL
	LD	HL,tilecolors
	LD	E,A
	LD	D,#00
	ADD	HL,DE
	LD	C,(HL)
	POP	HL
	SET	6,C
	LD	(HL),C
	INC	L
	LD	(HL),C
	LD	DE,#0020
	ADD	HL,DE
	LD	(HL),C
	DEC	L
	LD	(HL),C
	RET
        endif
;
tilecolors       DB       #06,#05,#07,#07,#07,#07,#07,#07
       DB       #06,#06,#06,#06,#06,#06,#06,#07
       DB       #07,#07,#07,#07,#07,#07,#07,#07
       DB       #07,#07,#07,#07,#07,#07,#07,#07
       DB       #07,#07,#07,#07,#07,#07,#07,#07
       DB       #07,#07
;
XYDEToScr
;D=X
;E=Y
	LD	A,E
	AND	#18
	OR	#40
	LD	H,A
	LD	A,E
	AND	#07
	OR	A
	RRA
	RRA
	RRA
	RRA
	ADD	A,D
	LD	L,A
	RET
;
L_BCF1	XOR	A
	LD	(stoptimer),A
	LD	DE,curgametimer
	LD	HL,tstarttime
	LD	BC,#0003
	LDIR
	LD	A,#19
	LD	(curtimerlow),A
	CALL	PrintGameTimer
	CALL	PrintNKeys
SetInt
	if 1==0
	DI
	LD	A,#FE
	LD	I,A
	LD	H,A
	IM	2
	LD	HL,L_FDFD
	LD	DE,Imer
	LD	(HL),#C3
	INC	L
	LD	(HL),E
	INC	L
	LD	(HL),D
	EI
	endif
	RET
;
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00
       
InitArrays
	LD	HL,unpackedlevel
	LD	DE,unpackedlevel+1
	LD	BC,#009F
	LD	(HL),#00
	LDIR
       if 1==0
	LD	HL,L_BE12
	LD	DE,L_BE12-1
	LD	BC,#000F
	LD	(HL),#01
	LDDR
       endif
	LD	HL,L_BEB3
	LD	DE,L_BEB3+1
	LD	BC,#000F
	LD	(HL),#01
	LDIR
	RES	1,(IY+#00)
	;CALL	GenerateScreenTable
	RET
;
      if 1==0
       DB       #00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00
       DB       #00
L_BE12       DB       #00
      endif
unpackedlevel       DB       #00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00
L_BEB3       DB       #00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00
;
curleveladdr       DB       #60,#EA
;
DrawLevel
	;DI
	RES	1,(IY+#00)
	LD	HL,unpackedlevel
	LD	E,#00
	LD	B,#0A
L_BEE9	PUSH	BC
	LD	D,#00
	LD	B,#10
L_BEEE	PUSH	BC
	PUSH	HL
	PUSH	DE
	LD	A,(HL)
	CALL	DrawTile_A_X2Y2DE
	POP	DE
	POP	HL
	POP	BC
	INC	D
	INC	HL
	DJNZ	L_BEEE
	POP	BC
	INC	E
	DJNZ	L_BEE9
	;EI
	RET
;
tilegfxbw       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #FF,#FE,#80,#02,#80,#02,#8A,#AA       ;.~.....*
       DB       #95,#52,#8F,#FA,#97,#FA,#8F,#FA       ;.R.z.z.z
       DB       #97,#FA,#8F,#FA,#97,#FA,#8F,#FA       ;.z.z.z.z
       DB       #97,#FA,#80,#02,#FF,#FE,#00,#00       ;.z...~..
       DB       #FF,#FE,#F8,#3E,#F3,#9E,#E4,#0E       ;.~x>s.d.
       DB       #E8,#0E,#C8,#06,#D0,#06,#D0,#06       ;h.H.P.P.
       DB       #D0,#06,#D0,#06,#D0,#06,#D0,#06       ;P.P.P.P.
       DB       #D0,#06,#C0,#06,#FF,#FE,#00,#00       ;P.@..~..
       DB       #FF,#FE,#F8,#3E,#E0,#0E,#C0,#06       ;.~x>`.@.
       DB       #C0,#06,#80,#02,#80,#02,#81,#02       ;@.......
       DB       #80,#02,#80,#02,#C0,#06,#C0,#06       ;....@.@.
       DB       #E0,#0E,#F8,#3E,#FF,#FE,#00,#00       ;`.x>.~..
       DB       #FF,#FE,#80,#02,#95,#52,#AA,#A2       ;.~...R*"
       DB       #95,#02,#A8,#02,#90,#02,#A8,#02       ;..(...(.
       DB       #90,#02,#A0,#02,#90,#02,#A0,#02       ;.. ... .
       DB       #80,#02,#80,#02,#FF,#FE,#00,#00       ;.....~..
       DB       #FF,#FE,#F8,#3E,#E0,#0E,#C1,#F6       ;.~x>`.Av
       DB       #C7,#F6,#C7,#F6,#CF,#F6,#CF,#D6       ;GvGvOvOV
       DB       #CF,#96,#CF,#D6,#CF,#F6,#CF,#F6       ;O.OVOvOv
       DB       #CF,#F6,#C0,#06,#FF,#FE,#00,#00       ;Ov@..~..
       DB       #FF,#FE,#80,#02,#BF,#FA,#A0,#0A       ;.~..?z .
       DB       #D0,#16,#E8,#2E,#F4,#5E,#FA,#BE       ;P.h.t^z>
       DB       #F4,#5E,#E9,#2E,#D7,#D6,#BF,#FA       ;t^i.WV?z
       DB       #BF,#FA,#80,#02,#FF,#FE,#00,#00       ;?z...~..
       DB       #AA,#AA,#7F,#FE,#FC,#7E,#7B,#BE       ;**.~|~{>
       DB       #FB,#BE,#7B,#BE,#FC,#7E,#7E,#FE       ;{>{>|~~~
       DB       #FE,#FE,#7E,#FE,#FE,#3E,#7E,#7E       ;~~~~~>~~
       DB       #FE,#3E,#7E,#FE,#FF,#FE,#00,#00       ;~>~~.~..
       DB       #FF,#FE,#80,#02,#BF,#FA,#BF,#FA       ;.~..?z?z
       DB       #BF,#FA,#EF,#FA,#CF,#FE,#80,#02       ;?zozO~..
       DB       #CF,#FE,#EF,#FA,#BF,#FA,#BF,#FA       ;O~oz?z?z
       DB       #BF,#FA,#80,#02,#FF,#FE,#00,#00       ;?z...~..
       DB       #FF,#FE,#80,#02,#BF,#FA,#BF,#FA       ;.~..?z?z
       DB       #BF,#FA,#BF,#EE,#FF,#E6,#80,#02       ;?z?n.f..
       DB       #FF,#E6,#BF,#EE,#BF,#FA,#BF,#FA       ;.f?n?z?z
       DB       #BF,#FA,#80,#02,#FF,#FE,#00,#00       ;?z...~..
       DB       #FF,#FE,#80,#02,#BF,#FA,#BF,#FA       ;.~..?z?z
       DB       #BF,#FA,#EF,#EE,#CF,#E6,#80,#02       ;?zonOf..
       DB       #CF,#E6,#EF,#EE,#BF,#FA,#BF,#FA       ;Ofon?z?z
       DB       #BF,#FA,#80,#02,#FF,#FE,#00,#00       ;?z...~..
       DB       #FF,#FE,#86,#C2,#BC,#7A,#B8,#3A       ;.~.B<z8:
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#BE,#FA       ;>z>z>z>z
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#B8,#3A       ;>z>z>z8:
       DB       #BC,#7A,#86,#C2,#FF,#FE,#00,#00       ;<z.B.~..
       DB       #FF,#FE,#86,#C2,#BC,#7A,#B8,#3A       ;.~.B<z8:
       DB       #BE,#FA,#EE,#EE,#CE,#E6,#80,#02       ;>znnNf..
       DB       #CE,#E6,#EE,#EE,#BE,#FA,#B8,#3A       ;Nfnn>z8:
       DB       #BC,#7A,#86,#C2,#FF,#FE,#00,#00       ;<z.B.~..
       DB       #FF,#FE,#82,#82,#BE,#FA,#BE,#FA       ;.~..>z>z
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#BE,#FA       ;>z>z>z>z
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#B8,#3A       ;>z>z>z8:
       DB       #BC,#7A,#86,#C2,#FF,#FE,#00,#00       ;<z.B.~..
       DB       #FF,#FE,#86,#C2,#BC,#7A,#B8,#3A       ;.~.B<z8:
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#BE,#FA       ;>z>z>z>z
       DB       #BE,#FA,#BE,#FA,#BE,#FA,#BE,#FA       ;>z>z>z>z
       DB       #BE,#FA,#82,#82,#FF,#FE,#00,#00       ;>z...~..
       DB       #AA,#AA,#7F,#FE,#FF,#FE,#7F,#FE       ;**.~.~.~
       DB       #FF,#FE,#7F,#FE,#FF,#FE,#7F,#FE       ;.~.~.~.~
       DB       #FF,#FE,#7F,#FE,#FF,#FE,#7F,#FE       ;.~.~.~.~
       DB       #FF,#FE,#7F,#FE,#FF,#FE,#00,#00       ;.~.~.~..
       DB       #FF,#FE,#F8,#3E,#F3,#9E,#E4,#0E       ;.~x>s.d.
       DB       #E8,#0E,#C8,#06,#D0,#06,#D0,#06       ;h.H.P.P.
       DB       #D1,#06,#D3,#86,#D7,#C6,#D1,#06       ;Q.S.WFQ.
       DB       #D1,#06,#C1,#06,#FD,#7E,#00,#00       ;Q.A.}~..
       DB       #00,#00,#00,#00,#3F,#F8,#20,#08       ;....?x .
       DB       #25,#48,#2A,#88,#24,#08,#28,#08       ;%H*.$.(.
       DB       #24,#08,#28,#08,#20,#08,#20,#08       ;$.(. . .
       DB       #3F,#F8,#00,#00,#00,#00,#00,#00       ;?x......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #0F,#E0,#08,#20,#0A,#A0,#09,#20       ;.`. . . 
       DB       #0A,#20,#08,#20,#0F,#E0,#00,#00       ;. . .`..
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#03,#80,#02,#80       ;........
       DB       #03,#80,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #FF,#FE,#F8,#3E,#E0,#0E,#C3,#86       ;.~x>`.C.
       DB       #CF,#E6,#8F,#E2,#9F,#F2,#9F,#F2       ;Of.b.r.r
       DB       #9F,#F2,#8F,#E2,#CF,#E6,#C3,#86       ;.r.bOfC.
       DB       #E0,#0E,#F8,#3E,#FF,#FE,#00,#00       ;`.x>.~..
       DB       #FF,#FE,#F8,#3E,#E0,#0E,#C0,#06       ;.~x>`.@.
       DB       #C0,#06,#83,#82,#87,#C2,#87,#C2       ;@....B.B
       DB       #87,#C2,#83,#82,#C0,#06,#C0,#06       ;.B..@.@.
       DB       #E0,#0E,#F8,#3E,#FF,#FE,#00,#00       ;`.x>.~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E0,#0E,#C0,#06,#C0,#06,#C0,#06       ;`.@.@.@.
       DB       #C0,#06,#C7,#C6,#CF,#E6,#CD,#66       ;@.GFOfMf
       DB       #C8,#26,#C0,#06,#FF,#FE,#00,#00       ;H&@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E0,#0E,#C0,#06,#C7,#C6,#CF,#E6       ;`.@.GFOf
       DB       #CD,#66,#C8,#26,#CD,#66,#CF,#E6       ;MfH&MfOf
       DB       #DF,#F6,#C0,#06,#FF,#FE,#00,#00       ;_v@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E7,#CE,#CF,#E6,#CD,#66,#C8,#26       ;gNOfMfH&
       DB       #CD,#66,#CF,#E6,#DF,#F6,#DC,#76       ;MfOf_v\v
       DB       #DE,#F6,#C0,#06,#FF,#FE,#00,#00       ;^v@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E7,#CE       ;.~x>p.gN
       DB       #EF,#EE,#CD,#66,#C8,#26,#CD,#66       ;onMfH&Mf
       DB       #CF,#E6,#DF,#F6,#DC,#76,#DE,#F6       ;Of_v\v^v
       DB       #DF,#F6,#C0,#06,#FF,#FE,#00,#00       ;_v@..~..
       DB       #FF,#FE,#F8,#3E,#F7,#DE,#EF,#EE       ;.~x>w^on
       DB       #ED,#6E,#C8,#26,#CD,#66,#CF,#E6       ;mnH&MfOf
       DB       #CF,#E6,#DC,#76,#DE,#F6,#BF,#FA       ;Of\v^v?z
       DB       #BF,#FA,#BF,#FA,#80,#02,#00,#00       ;?z?z....
       DB       #F0,#1E,#EF,#EE,#DE,#F6,#DE,#F6       ;p.on^v^v
       DB       #DE,#F6,#DE,#F6,#DE,#F6,#DE,#F6       ;^v^v^v^v
       DB       #DF,#F6,#BE,#FA,#BE,#FA,#7E,#FC       ;_v>z>z~|
       DB       #7F,#FC,#7E,#FC,#7F,#FC,#00,#00       ;.|~|.|..
       DB       #FF,#FE,#F8,#3E,#F7,#DE,#EE,#EE       ;.~x>w^nn
       DB       #EE,#EE,#CE,#E6,#CE,#E6,#CE,#E6       ;nnNfNfNf
       DB       #CF,#E6,#DE,#F6,#DE,#F6,#BF,#FA       ;Of^v^v?z
       DB       #BE,#FA,#BF,#FA,#80,#02,#00,#00       ;>z?z....
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E7,#CE       ;.~x>p.gN
       DB       #EE,#EE,#CE,#E6,#CE,#E6,#CF,#E6       ;nnNfNfOf
       DB       #CE,#E6,#DE,#F6,#DF,#F6,#DE,#F6       ;Nf^v_v^v
       DB       #DF,#F6,#C0,#06,#FF,#FE,#00,#00       ;_v@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E7,#CE,#CE,#E6,#CE,#E6,#CE,#E6       ;gNNfNfNf
       DB       #CF,#E6,#CE,#E6,#DE,#F6,#DF,#F6       ;OfNf^v_v
       DB       #DE,#F6,#C0,#06,#FF,#FE,#00,#00       ;^v@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E0,#0E,#C0,#06,#C7,#C6,#CE,#E6       ;`.@.GFNf
       DB       #CE,#E6,#CE,#E6,#CF,#E6,#CE,#E6       ;NfNfOfNf
       DB       #DE,#F6,#C0,#06,#FF,#FE,#00,#00       ;^v@..~..
       DB       #FF,#FE,#F8,#3E,#F0,#1E,#E0,#0E       ;.~x>p.`.
       DB       #E0,#0E,#C0,#06,#C0,#06,#C0,#06       ;`.@.@.@.
       DB       #C0,#06,#C7,#C6,#CE,#E6,#CE,#E6       ;@.GFNfNf
       DB       #CE,#E6,#C0,#06,#FF,#FE,#00,#00       ;Nf@..~..
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
;
ReadJoy
;A=0b111lrduf
	LD	H,#FF
	LD	BC,#7FFE
	IN	A,(C)
	BIT	2,A ;'M'
	JR	NZ,L_C66F
	RES	0,H
L_C66F	LD	A,#EF
	IN	A,(#FE) ;67890
	AND	H
	LD	H,A
	LD	A,#DF
	IN	A,(#FE)
	BIT	0,A ;'P'
	JR	NZ,L_C67F
	RES	3,H
L_C67F	BIT	1,A ;'O'
	JR	NZ,L_C685
	RES	4,H
L_C685	LD	A,#FB
	IN	A,(#FE)
	BIT	0,A ;'Q'
	JR	NZ,L_C68F
	RES	1,H
L_C68F	LD	A,#FD
	IN	A,(#FE)
	BIT	0,A ;'A'
	JR	NZ,L_C699
	RES	2,H
L_C699	LD	A,(kempstonon)
	OR	A
	LD	A,H
	RET	;Z
	IN	A,(#1F) ;kempston joystick
	CPL
	BIT	0,A
	JR	NZ,L_C6A8
	RES	3,H
L_C6A8	BIT	1,A
	JR	NZ,L_C6AE
	RES	4,H
L_C6AE	BIT	2,A
	JR	NZ,L_C6B4
	RES	2,H
L_C6B4	BIT	3,A
	JR	NZ,L_C6BA
	RES	1,H
L_C6BA	BIT	4,A
	JR	NZ,L_C6C0
	RES	0,H
L_C6C0	LD	A,H
;A=0b111lrduf
	RET
;
kempstonon       DB       #00
;
sprites ;64 bytes (2b spr, 2b mask)
       DB       #00,#00,#FF,#07,#00,#F8,#FE,#03       ;.....x~.
       DB       #01,#FC,#FC,#01,#01,#F8,#FC,#01       ;.||..x|.
       DB       #01,#F0,#FC,#01,#01,#F8,#FC,#01       ;.p|..x|.
       DB       #01,#FC,#FC,#01,#03,#FC,#F8,#01       ;.||..|x.
       DB       #03,#F0,#F8,#01,#03,#F8,#F8,#01       ;.px..xx.
       DB       #07,#FC,#F0,#01,#07,#CC,#F0,#01       ;.|p..Lp.
       DB       #0F,#B4,#E0,#01,#1F,#78,#80,#03       ;.4`..x..
       DB       #7F,#78,#00,#03,#00,#00,#00,#03       ;.x......
;
       DB       #00,#00,#FF,#07,#00,#F8,#FE,#03       ;.....x~.
       DB       #01,#FC,#FC,#01,#01,#F4,#FC,#01       ;.||..t|.
       DB       #01,#E0,#FC,#01,#01,#F4,#FC,#01       ;.`|..t|.
       DB       #01,#FC,#FC,#01,#03,#FC,#F8,#01       ;.||..|x.
       DB       #03,#F0,#F8,#01,#03,#F8,#F8,#01       ;.px..xx.
       DB       #03,#FC,#F8,#01,#07,#9C,#F0,#01       ;.|x...p.
       DB       #07,#6A,#F0,#00,#0E,#F6,#E0,#00       ;.jp..v`.
       DB       #1E,#F6,#C0,#00,#00,#00,#C0,#00       ;.v@...@.
;
       DB       #00,#00,#FF,#07,#00,#F8,#FE,#03       ;.....x~.
       DB       #01,#FC,#FC,#01,#01,#FC,#FC,#01       ;.||..||.
       DB       #01,#F8,#FC,#01,#01,#FC,#FC,#01       ;.x|..||.
       DB       #01,#FC,#FC,#01,#03,#FC,#F8,#01       ;.||..|x.
       DB       #03,#F0,#F8,#01,#03,#F8,#F8,#01       ;.px..xx.
       DB       #03,#FC,#F8,#01,#07,#F0,#F0,#01       ;.|x..pp.
       DB       #07,#EC,#F0,#01,#0F,#DE,#E0,#00       ;.lp..^`.
       DB       #1F,#DE,#C0,#00,#00,#00,#C0,#00       ;.^@...@.
;
       DB       #00,#00,#E0,#FF,#1F,#00,#C0,#7F       ;..`...@.
       DB       #3F,#80,#80,#3F,#1F,#80,#80,#3F       ;?..?...?
       DB       #0F,#80,#80,#3F,#1F,#80,#80,#3F       ;...?...?
       DB       #3F,#80,#80,#3F,#3F,#C0,#80,#1F       ;?..??@..
       DB       #0F,#C0,#80,#1F,#1F,#C0,#80,#1F       ;.@...@..
       DB       #3F,#E0,#80,#0F,#33,#E0,#80,#0F       ;?`..3`..
       DB       #2D,#F0,#80,#07,#1E,#F8,#C0,#01       ;-p...x@.
       DB       #1E,#FE,#C0,#00,#00,#00,#C0,#00       ;.~@...@.
;
       DB       #00,#00,#E0,#FF,#1F,#00,#C0,#7F       ;..`...@.
       DB       #3F,#80,#80,#3F,#2F,#80,#80,#3F       ;?..?/..?
       DB       #07,#80,#80,#3F,#2F,#80,#80,#3F       ;...?/..?
       DB       #3F,#80,#80,#3F,#3F,#C0,#80,#1F       ;?..??@..
       DB       #0F,#C0,#80,#1F,#1F,#C0,#80,#1F       ;.@...@..
       DB       #3F,#C0,#80,#1F,#39,#E0,#80,#0F       ;?@..9`..
       DB       #56,#E0,#00,#0F,#6F,#70,#00,#07       ;V`..op..
       DB       #6F,#78,#00,#03,#00,#00,#00,#03       ;ox......
;
       DB       #00,#00,#E0,#FF,#1F,#00,#C0,#7F       ;..`...@.
       DB       #3F,#80,#80,#3F,#3F,#80,#80,#3F       ;?..??..?
       DB       #1F,#80,#80,#3F,#3F,#80,#80,#3F       ;...??..?
       DB       #3F,#80,#80,#3F,#3F,#C0,#80,#1F       ;?..??@..
       DB       #0F,#C0,#80,#1F,#1F,#C0,#80,#1F       ;.@...@..
       DB       #3F,#C0,#80,#1F,#0F,#E0,#80,#0F       ;?@...`..
       DB       #37,#E0,#80,#0F,#7B,#F0,#00,#07       ;7`..{p..
       DB       #7B,#F8,#00,#03,#00,#00,#00,#03       ;{x......
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1F,#F0,#C0,#07,#3E,#F8,#80,#03       ;.p@.>x..
       DB       #3E,#F8,#80,#03,#7E,#FC,#00,#01       ;>x..~|..
       DB       #7F,#FC,#00,#01,#7E,#FC,#00,#01       ;.|..~|..
       DB       #7F,#FC,#00,#01,#00,#00,#00,#01       ;.|......
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#3E,#F0,#80,#07       ;.p@.>p..
       DB       #3E,#F0,#80,#07,#3D,#F8,#80,#03       ;>p..=x..
       DB       #7D,#F8,#00,#03,#7B,#F8,#00,#03       ;}x..{x..
       DB       #77,#F0,#00,#07,#CF,#F0,#00,#07       ;wp..Op..
       DB       #FE,#00,#00,#07,#00,#00,#00,#FF       ;~.......
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#1E,#F0,#C0,#07       ;.p@..p@.
       DB       #1E,#F0,#C0,#07,#1E,#F8,#C0,#03       ;.p@..x@.
       DB       #1E,#F8,#C0,#03,#3F,#78,#80,#03       ;.x@.?x..
       DB       #3F,#7C,#80,#01,#3F,#BC,#80,#01       ;?|..?<..
       DB       #1F,#DC,#C0,#01,#1F,#E6,#C0,#00       ;.\@..f@.
       DB       #00,#FE,#C0,#00,#00,#00,#FE,#00       ;.~@...~.
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1F,#F0,#C0,#07,#1B,#B0,#C0,#07       ;.p@..0@.
       DB       #11,#10,#C0,#07,#1B,#B0,#C0,#07       ;..@..0@.
       DB       #1F,#F0,#C0,#07,#1F,#F0,#C0,#07       ;.p@..p@.
       DB       #1C,#70,#C0,#07,#3E,#F8,#80,#03       ;.p@.>x..
       DB       #3F,#F8,#80,#03,#73,#9C,#00,#01       ;?x..s...
       DB       #6D,#6C,#00,#01,#5E,#F4,#00,#01       ;ml..^t..
       DB       #5E,#F4,#00,#01,#00,#00,#00,#01       ;^t......
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1F,#B0,#C0,#07,#1B,#10,#C0,#07       ;.0@...@.
       DB       #11,#B0,#C0,#07,#1B,#F0,#C0,#07       ;.0@..p@.
       DB       #1F,#F0,#C0,#07,#3F,#F0,#80,#07       ;.p@.?p..
       DB       #3C,#70,#80,#07,#3E,#F8,#80,#03       ;<p..>x..
       DB       #7F,#98,#00,#03,#73,#68,#00,#03       ;....sh..
       DB       #6C,#F0,#00,#07,#DE,#F0,#00,#07       ;lp..^p..
       DB       #DE,#00,#00,#07,#00,#00,#00,#FF       ;^.......
;
       DB       #00,#00,#F0,#1F,#0F,#E0,#E0,#0F       ;..p..``.
       DB       #1B,#F0,#C0,#07,#11,#B0,#C0,#07       ;.p@..0@.
       DB       #1B,#10,#C0,#07,#1F,#B0,#C0,#07       ;..@..0@.
       DB       #1F,#F0,#C0,#07,#1F,#F8,#C0,#03       ;.p@..x@.
       DB       #1C,#78,#C0,#03,#3E,#F8,#80,#03       ;.x@.>x..
       DB       #33,#FC,#80,#01,#2D,#9C,#80,#01       ;3|..-...
       DB       #1E,#6C,#C0,#01,#1E,#F6,#C0,#00       ;.l@..v@.
       DB       #00,#F6,#C0,#00,#00,#00,#FE,#00       ;.v@...~.
;
       DB       #3F,#F8,#00,#01,#00,#00,#7F,#FD       ;?x.....}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#00,#00,#7F,#FD       ;...}...}
       DB       #3F,#F8,#00,#01,#00,#00,#FF,#FF       ;?x......
;
       DB       #F1,#FE,#00,#01,#80,#02,#7F,#FD       ;q~.....}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#00,#7F,#FD,#80,#00,#7F,#FD       ;...}...}
       DB       #80,#00,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #00,#02,#7F,#FD,#00,#02,#7F,#FD       ;...}...}
       DB       #00,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #FF,#1E,#00,#01,#00,#00,#FF,#FF       ;........
;
       DB       #FF,#1E,#00,#01,#80,#02,#7F,#FD       ;.......}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #00,#02,#7F,#FD,#00,#02,#7F,#FD       ;...}...}
       DB       #00,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#00,#7F,#FD,#80,#00,#7F,#FD       ;...}...}
       DB       #80,#00,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #80,#02,#7F,#FD,#80,#02,#7F,#FD       ;...}...}
       DB       #E3,#FE,#00,#01,#00,#00,#FF,#FF       ;c~......
;
UnpackGamePanel
	LD	HL,#5800
	PUSH	HL
	POP	DE
	INC	E
	LD	BC,#02FF
	LD	(HL),L
	LDIR
	halt;DI
	CALL	reter;#0052
	DEC	SP
	DEC	SP
	POP	BC
	LD	HL,#0097
	ADD	HL,BC
	EX	DE,HL
	LD	HL,#0066
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#007B
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#0089
	ADD	HL,BC
	LD	(HL),E
	INC	HL
	LD	(HL),D
	LD	HL,#00BE
	ADD	HL,BC
	LD	DE,#4000
	PUSH	DE
	EXX
	EX	AF,AF' ;'
	LD	A,#03
	OR	A
	LD	B,#08
	LD	C,B
	POP	HL
	EX	AF,AF' ;'
	EXX
L_CB27	LD	A,(HL)
	BIT	7,A
	JR	NZ,L_CB66
	AND	#07
	LD	C,A
	LD	A,(HL)
	RRCA
	RRCA
	RRCA
	AND	#0F
	ADD	A,#03
	LD	B,A
	INC	HL
	LD	A,E
	SUB	(HL)
	INC	HL
	PUSH	HL
	LD	L,A
	LD	A,D
	SBC	A,C
	LD	H,A
L_CB41	PUSH	HL
	LD	A,H
	AND	#58
	CP	#58
	JR	Z,L_CB5B
	LD	C,A
	LD	A,L
	AND	#07
	OR	C
	LD	C,A
	ADD	HL,HL
	ADD	HL,HL
	LD	A,H
	AND	#1F
	LD	H,A
	LD	A,L
	AND	#E0
	OR	H
	LD	L,A
	LD	H,C
L_CB5B	LD	A,(HL)
	CALL	L_74A6
	POP	HL
	INC	HL
	DJNZ	L_CB41
	POP	HL
	JR	L_CB27
;
L_CB66	AND	#7F
	JR	Z,L_CB87
	INC	HL
	BIT	6,A
	JR	NZ,L_CB79
	LD	B,A
L_CB70	LD	A,(HL)
	CALL	L_74A6
	INC	HL
	DJNZ	L_CB70
	JR	L_CB27
;
L_CB79	AND	#3F
	ADD	A,#03
	LD	B,A
	LD	A,(HL)
L_CB7F	CALL	L_74A6
	DJNZ	L_CB7F
	INC	HL
	JR	L_CB27
;
L_CB87	EXX
	LD	HL,#2758
	EXX
	EI
	RET
;
       DB       #13,#D9,#77,#08,#28,#19,#24,#10       ;.Yw.(.$.
       DB       #1B,#11,#20,#F8,#19,#0D,#20,#12       ;.. x.. .
       DB       #11,#01,#FF,#19,#C6,#08,#30,#08       ;....F.0.
       DB       #11,#E0,#07,#19,#3D,#18,#01,#23       ;.`..=..#
       DB       #0E,#08,#06,#08,#08,#D9,#C9,#FF       ;.....YI.
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#FF,#00,#FF,#00,#FF       ;........
       DB       #00,#FF,#00,#EE,#00,#89,#FF,#80       ;...n....
       DB       #80,#95,#8A,#97,#8F,#97,#8F,#08       ;........
       DB       #04,#83,#97,#80,#FF,#E8,#00,#89       ;.....h..
       DB       #7F,#40,#40,#4A,#45,#4B,#47,#4B       ;.@@JEKGK
       DB       #47,#08,#04,#28,#08,#83,#4B,#40       ;G..(..K@
       DB       #7F,#E5,#00,#00,#6C,#82,#AA,#55       ;.e..l.*U
       DB       #C4,#FF,#81,#FE,#C6,#FF,#81,#00       ;D..~F...
       DB       #78,#83,#D4,#00,#18,#40,#8D,#FB       ;x.T..@.{
       DB       #F1,#E0,#FB,#BB,#3B,#00,#3B,#BB       ;q`{;;.;;
       DB       #FB,#E0,#F1,#FB,#78,#40,#D8,#00       ;{`q{x@X.
       DB       #20,#80,#C0,#FE,#85,#BE,#9E,#0E       ; .@~.>..
       DB       #9E,#BE,#00,#08,#78,#80,#D9,#00       ;.>..x.Y.
       DB       #20,#C0,#83,#00,#00,#1E,#C1,#2E       ; @....A.
       DB       #84,#7E,#42,#00,#AA,#78,#C0,#D9       ;.~B.*x@Y
       DB       #00,#30,#40,#88,#7C,#72,#72,#7C       ;.0@.|rr|
       DB       #70,#70,#00,#00,#78,#40,#DA,#00       ;pp..x@Z.
       DB       #30,#80,#88,#3C,#72,#72,#7E,#72       ;0..<rr~r
       DB       #72,#00,#00,#78,#80,#DA,#00,#30       ;r..x.Z.0
       DB       #C0,#00,#7F,#C0,#72,#82,#00,#00       ;@..@r...
       DB       #78,#C0,#DA,#00,#48,#80,#85,#72       ;x@Z.H..r
       DB       #72,#3C,#00,#00,#79,#00,#DA,#00       ;r<..y.Z.
       DB       #40,#80,#00,#BF,#78,#C0,#DD,#00       ;@..?x@].
       DB       #22,#40,#84,#3F,#7F,#3F,#7F,#08       ;"@.?.?..
       DB       #04,#83,#3F,#7F,#BF,#7A,#40,#D9       ;..?.?z@Y
       DB       #00,#3A,#80,#C2,#FE,#7A,#80,#DC       ;.:.B~z.\
       DB       #00,#1A,#C0,#8D,#E0,#83,#0F,#3B       ;..@.`..;
       DB       #3B,#7B,#7B,#7D,#7E,#3F,#3F,#9F       ;;{{}~??.
       DB       #E0,#7A,#C0,#D8,#00,#23,#00,#83       ;`z@X.#..
       DB       #3E,#DE,#DE,#C2,#EE,#83,#5E,#DE       ;>^^Bn.^^
       DB       #3E,#7B,#00,#D9,#00,#32,#80,#C5       ;>{.Y.2.E
       DB       #00,#7A,#80,#DA,#00,#78,#40,#7B       ;.z.Z.x@{
       DB       #80,#D9,#00,#78,#80,#7B,#C0,#D9       ;.Y.x.{@Y
       DB       #00,#79,#C0,#7C,#00,#D9,#00,#1C       ;.y@|.Y..
       DB       #40,#81,#FC,#C0,#FB,#81,#FC,#C5       ;@.|@{.|E
       DB       #FE,#7C,#40,#D8,#00,#1C,#80,#81       ;~|@X....
       DB       #7F,#C0,#BE,#81,#7E,#0A,#01,#82       ;.@>.~...
       DB       #3E,#7E,#79,#80,#DA,#00,#79,#80       ;>~y.Z.y.
       DB       #7C,#C0,#D9,#00,#7A,#C0,#7D,#00       ;|@Y.z@}.
       DB       #D9,#00,#85,#FE,#02,#02,#AA,#52       ;Y..~..*R
       DB       #CE,#FA,#82,#02,#FE,#EA,#00,#00       ;Nz..~j..
       DB       #2E,#82,#AA,#54,#C6,#FE,#81,#00       ;..*TF~..
       DB       #78,#3D,#D7,#00,#5E,#3B,#7E,#43       ;x=W.^;~C
       DB       #DD,#00,#00,#A9,#82,#54,#AA,#C8       ;]..).T*H
       DB       #FE,#7E,#00,#DB,#00,#85,#AA,#7F       ;~~.[..*.
       DB       #FF,#7F,#FF,#08,#04,#18,#08,#81       ;........
       DB       #00,#1E,#4C,#81,#00,#7E,#C3,#D4       ;..L..~CT
       DB       #00,#48,#7C,#08,#FC,#78,#40,#DB       ;.H|.|x@[
       DB       #00,#22,#40,#40,#85,#7E,#C0,#D9       ;."@@.~@Y
       DB       #00,#79,#C0,#79,#C0,#DE,#00,#85       ;.y@y@^..
       DB       #FF,#01,#01,#55,#A9,#C6,#FD,#81       ;...U)F}.
       DB       #01,#0F,#C0,#FF,#07,#FF,#07,#FF       ;..@.....
       DB       #07,#FF,#07,#FF,#07,#FF,#07,#FF       ;........
       DB       #07,#FF,#07,#FF,#07,#FF,#07,#4A       ;.......J
       DB       #94,#81,#05,#D4,#07,#00,#18,#82       ;...T....
       DB       #06,#06,#00,#1F,#10,#20,#C3,#06       ;..... C.
       DB       #20,#0A,#08,#10,#60,#20,#D0,#07       ; ...` P.
       DB       #20,#58,#81,#05,#80       ; X...
;
UnpackLevel
	;DI
	LD	DE,(curleveladdr)
	LD	HL,unpackedlevel
	LD	B,#50
L_CDFD	LD	A,(DE)
	AND	#F0
	RRCA
	RRCA
	RRCA
	RRCA
	LD	(HL),A
	INC	HL
	LD	A,(DE)
	AND	#0F
	LD	(HL),A
	INC	HL
	INC	DE
	DJNZ	L_CDFD
	LD	A,(DE)
	LD	HL,curyx
	LD	(HL),A
	INC	HL
	INC	DE
	LD	A,(DE)
	LD	(HL),A
	;EI
	RET
;y
curyx       DB       #78       ;x
;x
curx       DB       #E6       ;f
;
curtileaddr       DB       #00,#00       ;..
;
GameProcess
        if EGA == 0
	CALL	UnpackGamePanel
        endif
	RES	1,(IY+#00)
	CALL	DrawLevel

	XOR	A
	LD	(curnkeys),A
	CALL	L_BCF1
	CALL	L_DB37
	CALL	AnimateAppear
	LD	A,#09
	LD	(cursprite),A
L_CE39	LD	HL,buf24x16
	LD	DE,(curyx)
	CALL	GetBuf24x16_DEX2Y2
	LD	A,(cursprite)
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	LD	HL,tdrakon
       if EGA
	CALL	PrintStringHL_EGA
       else
	CALL	PrintStringHL
       endif
GoLoop
	CALL	RecodeCurTile
	LD	HL,(curtileaddr)
	LD	A,(HL) ;current tile?
	LD	D,#1B
	LD	E,#15
       if EGA == 0
	SET	1,(IY+#00)
	CALL	DrawTile_A_X2Y2DE ;no attr, XY (no X2Y2)
	RES	1,(IY+#00)
       else
	CALL	DrawTile_A_XYDE ;no attr, XY (no X2Y2)
       endif
;dragon control
GoBlock	CALL	GetCurTileTobuf24x16
	LD	A,(stoptimer)
	OR	A
	JP	M,Setstoptimer255
	CALL	ReadJoy ;A=0b111lrduf
	BIT	1,A ;up
	JP	Z,GoUp
	BIT	2,A ;down
	JP	Z,GoDown
	BIT	3,A ;right
	JP	Z,GoRight
	BIT	4,A ;left
	JP	Z,GoLeft
	LD	A,#7F
	IN	A,(#FE)
	BIT	0,A ;space
	JP	Z,GoToCursorMode
	LD	BC,#FEFE
	IN	A,(C)
	BIT	0,A ;caps shift
	JR	NZ,GoBlock
	LD	BC,#FBFE
	IN	A,(C)
	BIT	2,A ;'E'
	JP	Z,GO ;csE
	JR	GoBlock
;
GetBuf24x16_DEX2Y2
	CALL	X2Y2toxy_DE
	CALL	GetBuf24x16_DExy
	RET
;
X2Y2toxy_DE
	AND	A
	RL	D
	RL	D
	RL	D
	RL	D
	RL	E
	RL	E
	RL	E
	RL	E
	RET
;
recodedcurtile	DB	#00

RecodeCurTile
	CALL	countcurtileaddr
	LD	A,(HL)
	LD	HL,recodedcurtile
	LD	(HL),#00
	CP	#0C
	JR	NZ,L_CED4
	SET	0,(HL)
L_CED4	CP	#0B
	JR	NZ,L_CEDA
	SET	0,(HL)
L_CEDA	CP	#0E
	JR	NZ,L_CEE0
	SET	0,(HL)
L_CEE0	CP	#0C
	JR	NZ,L_CEE6
	SET	1,(HL)
L_CEE6	CP	#08
	JR	NZ,L_CEEC
	SET	1,(HL)
L_CEEC	CP	#0A
	JR	NZ,L_CEF2
	SET	1,(HL)
L_CEF2	CP	#0C
	JR	NZ,L_CEF8
	SET	2,(HL)
L_CEF8	CP	#09
	JR	NZ,L_CEFE
	SET	2,(HL)
L_CEFE	CP	#0A
	JR	NZ,L_CF04
	SET	2,(HL)
L_CF04	CP	#0C
	JR	NZ,L_CF0A
	SET	3,(HL)
L_CF0A	CP	#0D
	JR	NZ,L_CF10
	SET	3,(HL)
L_CF10	CP	#0B
	RET	NZ
	SET	3,(HL)
	RET
;
countcurtileaddr
	LD	A,(curyx)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	L,A
	LD	H,#00
	LD	D,H
	LD	A,(curx)
	LD	E,A
	ADD	HL,DE
	LD	DE,unpackedlevel
	ADD	HL,DE
	LD	(curtileaddr),HL
	RET
;
GoLeft	LD	HL,(curtileaddr)
	DEC	HL
	LD	A,(HL)
	OR	A
	JP	Z,GoLeftEmptyTile
	CP	#01 ;block
	JP	Z,GoBlock
	CP	#03 ;teleport
	JP	Z,GoLeftTeleport
	CP	#02 ;exit
	JP	Z,GoLeftLevelExit
	CP	#05 ;closed door
	JP	Z,GoLeftClosedDoor
	CP	#06 ;hourglass
	JP	Z,GoLeftHourglass
	CP	#07 ;key
	JP	Z,GoLeftKey
	CALL	GoLeftAnim
	JP	GoLoop
;
GoLeftEmptyTile
	LD	HL,recodedcurtile
	LD	A,(HL)
	BIT	1,A
	JP	Z,GoBlock
	LD	HL,(curtileaddr)
	LD	C,#FF
	XOR	A
L_CF6A	DEC	HL
	INC	C
	CP	(HL)
	JR	Z,L_CF6A
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	A,#03
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	LD	DE,(curyx)
	LD	HL,gettilebuf2
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
	HALT
L_CFAE	CALL	ClearTile_DExy
	DEC	D
	LD	HL,gettilebuf2
	CALL	DrawSprite16x16_HL_DExy
	CALL	Halter
	DJNZ	L_CFAE
	LD	HL,(curtileaddr)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	INC	HL
	LD	(HL),A
	LD	(curtileaddr),HL
	LD	A,(curx)
	SUB	C
	LD	(curx),A
	JP	GoBlock
;
L_CFD4       DB       #00
;
GoLeftAnim
	LD	A,(curx)
	DEC	A
	LD	(curx),A
	LD	DE,(curyx)
	INC	D
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	DE,(curyx)
	INC	D
	PUSH	DE
	CALL	X2Y2toxy_DE
	PUSH	DE
	PUSH	DE
	LD	HL,buf24x16
	CALL	GetBuf24x16_DExy
	LD	A,#03
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	POP	DE
	LD	B,#08
	EI
	HALT
L_D006	PUSH	BC
	PUSH	BC
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	DEC	D
	DEC	D
	LD	HL,buf24x16
	PUSH	DE
	CALL	GetBuf24x16_DExy
	POP	DE
	POP	BC
	PUSH	DE
	CALL	L_B7DF
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	CALL	Halter5_
	POP	BC
	DJNZ	L_D006
	CALL	GetCurTileTobuf24x16
	POP	DE
	LD	HL,(curtileaddr)
	INC	HL
L_D02F	LD	A,(HL)
	CP	#04
	RET	NZ
	LD	(HL),#00
	PUSH	DE
	PUSH	DE
	PUSH	DE
	LD	A,#11 ;falling glass
	CALL	DrawTile_A_X2Y2DE
	POP	DE
	CALL	Halter5
	LD	A,#12
	CALL	DrawTile_A_X2Y2DE
	POP	DE
	CALL	Halter5
	LD	A,#13
	CALL	DrawTile_A_X2Y2DE
	POP	DE
	CALL	Halter5
	XOR	A
	CALL	DrawTile_A_X2Y2DE
	RET
;
GoLeftTeleport
	CALL	GoLeftAnim
GoTeleport
	LD	HL,unpackedlevel
	LD	E,#00
	LD	D,#00
L_D062	LD	A,(HL)
	CP	#03
	JR	NZ,L_D068
	PUSH	DE
L_D068	INC	HL
	INC	D
	LD	A,#10
	CP	D
	JR	NZ,L_D062
	LD	D,#00
	INC	E
	LD	A,#0A
	CP	E
	JR	NZ,L_D062
	POP	HL
	PUSH	HL
	LD	DE,(curyx)
	AND	A
	SBC	HL,DE
	LD	A,H
	OR	L
	JR	Z,L_D088
	POP	HL
	POP	DE
	JR	L_D08A
L_D088	POP	DE
	POP	HL
L_D08A	PUSH	HL
	PUSH	DE
	PUSH	DE
	LD	A,#14 ;teleport
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter6
	POP	DE
	LD	A,#15
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter6
	POP	DE
	LD	A,#03
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter6
	POP	DE
	PUSH	DE
	PUSH	DE
	LD	A,#15
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter6
	POP	DE
	LD	A,#14
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter6
	POP	DE
	PUSH	DE
	LD	(curyx),DE
	LD	A,#03
	CALL	DrawTile_A_X2Y2DE
	POP	DE
	PUSH	DE
	LD	HL,buf24x16
	CALL	GetBuf24x16_DEX2Y2
	POP	DE
	LD	A,(cursprite)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	JP	GoLoop
;
cursprite       DB       #00
curnkeys       DB       #00
;
       DB       #CD,#FF,#D0,#ED,#5B,#19,#CE,#CD       ;M.Pm[.NM
       DB       #B2,#CE,#21,#E6,#BA,#CD,#85,#BA       ;2N!f:M.:
       DB       #CD,#FF,#D0,#ED,#5B,#19,#CE,#CD       ;M.Pm[.NM
       DB       #B2,#CE,#3E,#03,#CD,#AC,#B9,#C3       ;2N>.M,9C
       DB       #6C,#CE       ;lN
;
       if EGA == 0
GetCurTileTobuf24x16
	CALL	countcurtileaddr
	LD	DE,tilegfxbw
	LD	L,(HL)
	LD	H,#00
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	ADD	HL,HL
	PUSH	HL
	POP	IX
	LD	DE,(curtileaddr)
	AND	A
	RL	D
	RL	E
	CALL	XYDEToScr
	LD	DE,buf24x16
	INC	HL
	INC	HL
	LD	B,#10
L_D123	LD	A,(IX+#00)
	LD	(DE),A
	INC	DE
	LD	A,(IX+#01)
	LD	(DE),A
	INC	DE
	LD	A,(HL)
	LD	(DE),A
	INC	H
	CALL	DownHL
	INC	DE
	INC	IX
	INC	IX
	DJNZ	L_D123
	RET
       endif
;
Halter6	HALT
	HALT
	HALT
	HALT
	HALT
	HALT
	RET
;
GoLeftHourglass
	LD	(HL),#0F
	LD	DE,(curyx)
	DEC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GetHourglass
	CALL	GoLeftAnim
	JP	GoLoop
;
GoLeftKey
	LD	(HL),#0F
	LD	DE,(curyx)
	DEC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoLeftAnim
	LD	HL,curnkeys
	INC	(HL)
	CALL	PrintNKeys
	JP	GoLoop
;
GoLeftClosedDoor
	LD	A,(curnkeys)
	OR	A
	JP	Z,GoBlock
	DEC	A
	LD	(curnkeys),A
	LD	(HL),#0F
	CALL	PrintNKeys
	LD	DE,(curyx)
	DEC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoLeftAnim
	JP	GoLoop
;
GoLeftLevelExit
	CALL	GoLeftAnim
	JP	LevelExit
;
GoRight
	LD	HL,(curtileaddr)
	INC	HL
	LD	A,(HL)
	OR	A
	JP	Z,GoRightEmptyTile
	CP	#01
	JP	Z,GoBlock
	CP	#03
	JP	Z,GoRightTeleport
	CP	#05
	JP	Z,GoRightClosedDoor
	CP	#06
	JP	Z,GoRightHourglass
	CP	#07
	JP	Z,GoRightKey
	CP	#02
	JP	Z,GoRightLevelExit
	CALL	GoRightAnim
	JP	GoLoop
;
GoRightEmptyTile
	LD	HL,recodedcurtile
	BIT	2,(HL)
	JP	Z,GoBlock
	LD	HL,(curtileaddr)
	LD	C,#FF
	XOR	A
L_D1D1	INC	HL
	INC	C
	CP	(HL)
	JR	Z,L_D1D1
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	A,#00
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	LD	DE,(curyx)
	LD	HL,gettilebuf2
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
	HALT
L_D215	CALL	ClearTile_DExy
	INC	D
	LD	HL,gettilebuf2
	CALL	DrawSprite16x16_HL_DExy
	CALL	Halter
	DJNZ	L_D215
	LD	HL,(curtileaddr)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	DEC	HL
	LD	(HL),A
	LD	(curtileaddr),HL
	LD	A,(curx)
	ADD	A,C
	LD	(curx),A
	JP	GoBlock
;
GoRightAnim
	LD	A,(curx)
	INC	A
	LD	(curx),A
	LD	DE,(curyx)
	DEC	D
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	DE,(curyx)
	DEC	D
	PUSH	DE
	CALL	X2Y2toxy_DE
	PUSH	DE
	PUSH	DE
	LD	HL,buf24x16
	CALL	GetBuf24x16_DExy
	LD	A,#00
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	POP	DE
	LD	B,#08
	EI
	HALT
L_D26C	PUSH	BC
	PUSH	BC
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	INC	D
	INC	D
	LD	HL,buf24x16
	PUSH	DE
	CALL	GetBuf24x16_DExy
	POP	DE
	POP	BC
	PUSH	DE
	CALL	L_D29E
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	CALL	Halter5_
	POP	BC
	DJNZ	L_D26C
	CALL	GetCurTileTobuf24x16
	POP	DE
	LD	HL,(curtileaddr)
	DEC	HL
	JP	L_D02F
;
GoRightTeleport
	CALL	GoRightAnim
	JP	GoTeleport
;
L_D29E	PUSH	DE
	LD	A,#08
	CP	B
	LD	HL,L_D2B1
	JR	Z,L_D2AA
	LD	HL,#0000
L_D2A8       EQU       $-2
L_D2AA	LD	A,(HL)
	INC	HL
	LD	(L_D2A8),HL
	POP	DE
	RET
;
L_D2B1       DB       #01,#02,#00,#01,#02,#00,#01,#00
;
GoRightHourglass
	LD	(HL),#0F
	LD	DE,(curyx)
	INC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GetHourglass
	CALL	GoRightAnim
	JP	GoLoop
;
GoRightKey
	LD	(HL),#0F
	LD	DE,(curyx)
	INC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoRightAnim
	LD	HL,curnkeys
	INC	(HL)
	CALL	PrintNKeys
	JP	GoLoop
;
GoRightClosedDoor
	LD	A,(curnkeys)
	OR	A
	JP	Z,GoBlock
	DEC	A
	LD	(curnkeys),A
	LD	(HL),#0F
	CALL	PrintNKeys
	LD	DE,(curyx)
	INC	D
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoRightAnim
	JP	GoLoop
;
GoRightLevelExit
	CALL	GoRightAnim
	JP	LevelExit
;
GoUp
	LD	HL,(curtileaddr)
	AND	A
	LD	BC,#0010
	SBC	HL,BC
	LD	A,(HL)
	OR	A
	JP	Z,GoUpEmptyTile
	CP	#01
	JP	Z,GoBlock
	CP	#02
	JP	Z,GoUpLevelExit
	CP	#03
	JP	Z,GoUpTeleport
	CP	#05
	JP	Z,GoUpClosedDoor
	CP	#06
	JP	Z,GoUpHourglass
	CP	#07
	JP	Z,GoUpKey
	CALL	GoUpAnim
	JP	GoLoop
;
GoUpEmptyTile
	LD	HL,recodedcurtile
	BIT	0,(HL)
	JP	Z,GoBlock
	LD	HL,(curtileaddr)
	LD	C,#FF
	XOR	A
L_D34D	AND	A
	LD	DE,#0010
	SBC	HL,DE
	INC	C
	CP	(HL)
	JR	Z,L_D34D
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	A,#06
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	LD	DE,(curyx)
	LD	HL,gettilebuf2
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
	HALT
L_D396	CALL	Halter
	DEC	E
	LD	HL,gettilebuf2
	CALL	DrawSprite16x16_HL_DExy
	PUSH	DE
	LD	A,#10
	ADD	A,E
	CALL	Clear2Bytes_ADyx
	POP	DE
	DJNZ	L_D396
	LD	HL,(curtileaddr)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	LD	DE,#0010
	ADD	HL,DE
	LD	(HL),A
	LD	(curtileaddr),HL
	LD	A,(curyx)
	SUB	C
	LD	(curyx),A
	JP	GoBlock
;
GoUpAnim
	LD	A,(curyx)
	DEC	A
	LD	(curyx),A
	LD	DE,(curyx)
	INC	E
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	DE,(curyx)
	INC	E
	PUSH	DE
	CALL	X2Y2toxy_DE
	PUSH	DE
	PUSH	DE
	LD	HL,buf24x16
	CALL	GetBuf24x16_DExy
	LD	A,#06
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	POP	DE
	LD	B,#08
	EI
	HALT
L_D3F5	PUSH	BC
	PUSH	BC
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	DEC	E
	DEC	E
	LD	HL,buf24x16
	PUSH	DE
	CALL	GetBuf24x16_DExy
	POP	DE
	POP	BC
	PUSH	DE
	CALL	L_D47E
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	CALL	Halter5_
	POP	BC
	DJNZ	L_D3F5
	CALL	GetCurTileTobuf24x16
	POP	DE
	LD	HL,(curtileaddr)
	LD	BC,#0010
	ADD	HL,BC
	JP	L_D02F
;
GoUpTeleport
	CALL	GoUpAnim
	JP	GoTeleport
;
GoUpHourglass
	LD	(HL),#0F
	LD	DE,(curyx)
	DEC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GetHourglass
	CALL	GoUpAnim
	JP	GoLoop
;
GoUpKey
	LD	(HL),#0F
	LD	DE,(curyx)
	DEC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoUpAnim
	LD	HL,curnkeys
	INC	(HL)
	CALL	PrintNKeys
	JP	GoLoop
;
GoUpLevelExit
	CALL	GoUpAnim
	JP	LevelExit
;
GoUpClosedDoor
	LD	A,(curnkeys)
	OR	A
	JP	Z,GoBlock
	DEC	A
	LD	(curnkeys),A
	LD	(HL),#0F
	CALL	PrintNKeys
	LD	DE,(curyx)
	DEC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoUpAnim
	JP	GoLoop
;
L_D47E	PUSH	DE
	LD	A,#08
	CP	B
	LD	HL,L_D491
	JR	Z,L_D48A
	LD	HL,#0000
L_D488       EQU       $-2
L_D48A	LD	A,(HL)
	INC	HL
	LD	(L_D488),HL
	POP	DE
	RET
;
L_D491
       DB       #07,#08,#06,#07,#08,#06,#07,#06
;
GoDown
	LD	HL,(curtileaddr)
	LD	BC,#0010
	ADD	HL,BC
	LD	A,(HL)
	OR	A
	JP	Z,GoDownEmptyTile
	CP	#01
	JP	Z,GoBlock
	CP	#02
	JP	Z,GoDownLevelExit
	CP	#03
	JP	Z,GoDownTeleport
	CP	#05
	JP	Z,GoDownClosedDoor
	CP	#06
	JP	Z,GoDownHourglass
	CP	#07
	JP	Z,GoDownKey
	CALL	GoDownAnim
	JP	GoLoop
;
GoDownEmptyTile
	LD	HL,recodedcurtile
	BIT	3,(HL)
	JP	Z,GoBlock
	LD	HL,(curtileaddr)
	LD	C,#FF
	XOR	A
	LD	DE,#0010
L_D4DA	ADD	HL,DE
	INC	C
	CP	(HL)
	JR	Z,L_D4DA
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	A,#09
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	CALL	DrawSprite_Akeep_DExy
	LD	DE,(curyx)
	LD	HL,gettilebuf2
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(curyx)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
	HALT
L_D51E	CALL	Halter
	INC	E
	LD	HL,gettilebuf2
	CALL	DrawSprite16x16_HL_DExy
	PUSH	DE
	DEC	E
	LD	A,E
	CALL	Clear2Bytes_ADyx
	POP	DE
	DJNZ	L_D51E
	LD	HL,(curtileaddr)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	AND	A
	LD	DE,#0010
	SBC	HL,DE
	LD	(HL),A
	LD	(curtileaddr),HL
	LD	A,(curyx)
	ADD	A,C
	LD	(curyx),A
	JP	GoBlock
;
GoDownAnim	LD	A,(curyx)
	INC	A
	LD	(curyx),A
	LD	DE,(curyx)
	DEC	E
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	LD	DE,(curyx)
	DEC	E
	PUSH	DE
	CALL	X2Y2toxy_DE
	PUSH	DE
	PUSH	DE
	LD	HL,buf24x16
	CALL	GetBuf24x16_DExy
	LD	A,#09
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	POP	DE
	LD	B,#08
	EI
	HALT
L_D57E	PUSH	BC
	PUSH	BC
	LD	HL,buf24x16
	CALL	ReBuf24x16_DExy
	INC	E
	INC	E
	LD	HL,buf24x16
	PUSH	DE
	CALL	GetBuf24x16_DExy
	POP	DE
	POP	BC
	PUSH	DE
	CALL	L_D609
	POP	DE
	CALL	DrawSprite_Akeep_DExy
	CALL	Halter5_
	POP	BC
	DJNZ	L_D57E
	CALL	GetCurTileTobuf24x16
	POP	DE
	AND	A
	LD	BC,#0010
	LD	HL,(curtileaddr)
	SBC	HL,BC
	JP	L_D02F
;
GoDownTeleport
	CALL	GoDownAnim
	JP	GoTeleport
;
GoDownLevelExit
	CALL	GoDownAnim
	JP	LevelExit
;
GoDownHourglass
	LD	(HL),#0F
	LD	DE,(curyx)
	INC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GetHourglass
	CALL	GoDownAnim
	JP	GoLoop
;
GoDownKey
	LD	(HL),#0F
	LD	DE,(curyx)
	INC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoDownAnim
	LD	HL,curnkeys
	INC	(HL)
	CALL	PrintNKeys
	JP	GoLoop
;
GoDownClosedDoor
	LD	A,(curnkeys)
	OR	A
	JP	Z,GoBlock
	DEC	A
	LD	(curnkeys),A
	LD	(HL),#0F
	CALL	PrintNKeys
	LD	DE,(curyx)
	INC	E
	LD	A,#0F
	CALL	DrawTile_A_X2Y2DE
	CALL	GoDownAnim
	JP	GoLoop
;
L_D609	PUSH	DE
	LD	A,#08
	CP	B
	LD	HL,L_D61C
	JR	Z,L_D615
	LD	HL,#0000
L_D613       EQU       $-2
L_D615	LD	A,(HL)
	INC	HL
	LD	(L_D613),HL
	POP	DE
	RET
;
L_D61C       DB       #0A,#0B,#09,#0A,#0B,#09,#0A,#09
;
GoToCursorMode
	CALL	WaitNoKey
	LD	HL,tkursor
       if EGA
	CALL	PrintStringHL_EGA
       else
	CALL	PrintStringHL
       endif
	LD	HL,(curyx)
	LD	(L_D70E),HL
	LD	DE,buf24x16_2
	EX	DE,HL
	CALL	X2Y2toxy_DE
L_D63A	CALL	GetBuf24x16_DExy
L_D63D	CALL	L_D68A
	CALL	GetCurTileTobuf24x16
	LD	A,(stoptimer)
	OR	A
	JP	M,Setstoptimer255
	;LD	HL,#32C8
	;CALL	PauseHL
         call Halter5 ;fix for turbo
	CALL	ReadJoy ;A=0b111lrduf
	BIT	0,A
	JP	Z,CursorFire
	BIT	1,A
	JP	Z,CursorUp
	BIT	2,A
	JP	Z,CursorDown
	BIT	3,A
	JP	Z,CursorRight
	BIT	4,A
	JP	Z,CursorLeft
	LD	A,#7F
	IN	A,(#FE)
	BIT	0,A ;Space
	JP	Z,L_D8B7
	LD	BC,#FEFE
	IN	A,(C)
	BIT	0,A
	JR	NZ,L_D63D
	LD	BC,#FBFE
	IN	A,(C)
	BIT	2,A
	JP	Z,GO
	JR	L_D63D
;
L_D68A	LD	A,#0B
L_D68B=$-1
	INC	A
	CP	#0F
	JR	NZ,L_D693
	LD	A,#0C
L_D693	LD	(L_D68B),A ;cursor tile
	PUSH	AF
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	PUSH	DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	POP	DE
	POP	AF
	CALL	DrawSprite_A_DExy
	RET
;
CursorLeft	LD	A,(L_D70F)
	OR	A
	JP	Z,L_D63D
	PUSH	AF
	LD	DE,(L_D70E)
	PUSH	DE
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	POP	DE
	POP	AF
	DEC	A
	LD	(L_D70F),A
	DEC	D
	LD	HL,buf24x16_2
	CALL	X2Y2toxy_DE
	CALL	GetBuf24x16_DExy
	JP	L_D63D
;
CursorFire
	CALL	L_D710
	PUSH	HL
	LD	DE,(curtileaddr)
	AND	A
	SBC	HL,DE
	LD	A,H
	OR	L
	POP	HL
	JP	Z,L_D63D
	LD	A,(HL)
	CP	#08
	JP	Z,CursorFireOK
	CP	#09
	JP	Z,CursorFireOK
	CP	#0A
	JP	Z,CursorFireOK
	CP	#0B
	JP	Z,CursorFireOK
	CP	#0C
	JP	Z,CursorFireOK
	CP	#0D
	JP	Z,CursorFireOK
	CP	#0E
	JP	Z,CursorFireOK
	JP	L_D63D
;
L_D70C       DB       #00,#00
L_D70E       DB       #00
L_D70F       DB       #00
;
L_D710	LD	DE,(L_D70E)
	LD	A,E
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	HL,unpackedlevel
	LD	D,#00
	LD	E,A
	ADD	HL,DE
	LD	DE,(L_D70E)
	LD	E,D
	LD	D,#00
	ADD	HL,DE
	LD	(L_D70C),HL
	RET
;
CursorFireOK2
	LD	HL,buf24x16_2
	LD	DE,(L_D70E)
	CALL	WaitNoKey
	CALL	X2Y2toxy_DE
	PUSH	DE
	CALL	ReBuf24x16_DExy
	POP	DE
L_D73E	DB	#00
	DB	#00
L_D740	CALL	L_D78A
	LD	A,(stoptimer)
	OR	A
	JP	M,Setstoptimer255
	CALL	ReadJoy ;A=0b111lrduf
	BIT	3,A
	JP	Z,CursorFireRight
	BIT	1,A
	JP	Z,CursorFireUp
	BIT	2,A
	JP	Z,CursorFireDown
	BIT	4,A
	JP	Z,CursorFireLeft
	BIT	0,A
	JP	Z,CursorFireFire
	LD	A,#7F
	IN	A,(#FE)
	BIT	0,A
	JP	Z,L_D8B7
	JP	L_D740
;
CursorFireFire	CALL	WaitNoKey
	LD	HL,buf24x16_2
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	PUSH	DE
	CALL	ReBuf24x16_DExy
	POP	DE
	LD	HL,buf24x16_2
	JP	L_D63A
;
L_D78A	CALL	L_D710
	LD	A,(HL)
	LD	HL,L_D83B
	LD	(HL),#00
	CP	#0C
	JR	NZ,L_D79F
	SET	0,(HL)
	SET	1,(HL)
	SET	2,(HL)
	SET	3,(HL)
L_D79F	CP	#0B
	JR	NZ,L_D7A7
	SET	0,(HL)
	SET	3,(HL)
L_D7A7	CP	#0A
	JR	NZ,L_D7AF
	SET	1,(HL)
	SET	2,(HL)
L_D7AF	CP	#08
	JR	NZ,L_D7B5
	SET	1,(HL)
L_D7B5	CP	#09
	JR	NZ,L_D7BB
	SET	2,(HL)
L_D7BB	CP	#0E
	JR	NZ,L_D7C1
	SET	0,(HL)
L_D7C1	CP	#0D
	RET	NZ
	SET	3,(HL)
	RET
;
CursorFireLeft
	LD	HL,L_D83B
	BIT	1,(HL)
	JP	Z,L_D740
	LD	HL,(L_D70C)
	LD	C,#FF
	XOR	A
L_D7D5	DEC	HL
	INC	C
	CP	(HL)
	JR	Z,L_D7D5
	OR	C
	JP	Z,L_D740
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	LD	DE,(L_D70E)
	LD	HL,gettilebuf
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
L_D810	CALL	ClearTile_DExy
	DEC	D
	LD	HL,gettilebuf
	CALL	DrawSprite16x16_HL_DExy
	HALT
	DJNZ	L_D810
	LD	HL,(L_D70C)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	INC	HL
	LD	(HL),A
	LD	(L_D70C),HL
	LD	A,(L_D70F)
	SUB	C
	LD	(L_D70F),A
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	JP	L_D73E
;
L_D83B
       DB       #00

        if EGA == 0
gettilebuf
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00
        endif
;
        if 1==0
PauseHL	DEC	HL
	LD	A,H
	OR	L
	RET	Z
	JR	PauseHL
        endif
;
        if EGA == 0
buf24x16_2
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00,#00,#00,#00,#00,#00,#00
       DB       #00,#00
        endif
;
CursorFireOK
	CALL	WaitNoKey
	JP	CursorFireOK2
;
WaitNoKey
	XOR	A
	IN	A,(#FE)
	AND	#1F
	CP	#1F
	HALT
	RET	Z
	JR	WaitNoKey
;
L_D8B7
	LD	DE,(L_D70E)
	LD	HL,buf24x16_2
	CALL	X2Y2toxy_DE
	CALL	ReBuf24x16_DExy
	CALL	WaitNoKey
	LD	DE,(curyx)
	LD	HL,(curtileaddr)
	LD	A,(HL)
	CALL	DrawTile_A_X2Y2DE
	JP	L_CE39
;
CursorRight
	LD	A,(L_D70F)
	CP	#0F
	JP	Z,L_D63D
	PUSH	AF
	LD	DE,(L_D70E)
	PUSH	DE
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	POP	DE
	POP	AF
	INC	A
	LD	(L_D70F),A
	INC	D
	LD	HL,buf24x16_2
	CALL	X2Y2toxy_DE
	CALL	GetBuf24x16_DExy
	JP	L_D63D
;
CursorUp
	LD	A,(L_D70E)
	OR	A
	JP	Z,L_D63D
	PUSH	AF
	LD	DE,(L_D70E)
	PUSH	DE
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	POP	DE
	POP	AF
	DEC	A
	LD	(L_D70E),A
	DEC	E
	LD	HL,buf24x16_2
	CALL	X2Y2toxy_DE
	CALL	GetBuf24x16_DExy
	JP	L_D63D
;
CursorDown
	LD	A,(L_D70E)
	CP	#09
	JP	Z,L_D63D
	PUSH	AF
	LD	DE,(L_D70E)
	PUSH	DE
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	POP	DE
	POP	AF
	INC	A
	LD	(L_D70E),A
	INC	E
	LD	HL,buf24x16_2
	CALL	X2Y2toxy_DE
	CALL	GetBuf24x16_DExy
	JP	L_D63D
;
CursorFireRight
	LD	HL,L_D83B
	BIT	2,(HL)
	JP	Z,L_D740
	LD	HL,(L_D70C)
	LD	C,#FF
	XOR	A
L_D960	INC	HL
	INC	C
	CP	(HL)
	JR	Z,L_D960
	OR	C
	JP	Z,L_D740
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	LD	DE,(L_D70E)
	LD	HL,gettilebuf
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
L_D99B	CALL	ClearTile_DExy
	INC	D
	LD	HL,gettilebuf
	CALL	DrawSprite16x16_HL_DExy
	HALT
	DJNZ	L_D99B
	LD	HL,(L_D70C)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	DEC	HL
	LD	(HL),A
	LD	(L_D70C),HL
	LD	A,(L_D70F)
	ADD	A,C
	LD	(L_D70F),A
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	JP	L_D73E
;
CursorFireUp
	LD	HL,L_D83B
	BIT	0,(HL)
	JP	Z,L_D740
	LD	HL,(L_D70C)
	LD	C,#FF
	XOR	A
	LD	DE,#0010
L_D9D7	AND	A
	SBC	HL,DE
	INC	C
	CP	(HL)
	JR	Z,L_D9D7
	OR	C
	JP	Z,L_D740
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	LD	DE,(L_D70E)
	LD	HL,gettilebuf
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
L_DA14	CALL	ClearTile_DExy
	DEC	E
	LD	HL,gettilebuf
	CALL	DrawSprite16x16_HL_DExy
	HALT
	DJNZ	L_DA14
	LD	HL,(L_D70C)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	LD	DE,#0010
	ADD	HL,DE
	LD	(HL),A
	LD	(L_D70C),HL
	LD	A,(L_D70E)
	SUB	C
	LD	(L_D70E),A
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	JP	L_D73E
;
CursorFireDown
	LD	HL,L_D83B
	BIT	3,(HL)
	JP	Z,L_D740
	LD	HL,(L_D70C)
	LD	C,#FF
	XOR	A
	LD	DE,#0010
L_DA53	ADD	HL,DE
	INC	C
	CP	(HL)
	JR	Z,L_DA53
	OR	C
	JP	Z,L_D740
	LD	A,C
	LD	(L_CFD4),A
	PUSH	HL
	PUSH	BC
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	HL,buf24x16_2
	CALL	ReBuf24x16_DExy
	LD	DE,(L_D70E)
	LD	HL,gettilebuf
	AND	A
	RL	D
	RL	E
	CALL	GetTileToHL_DEXY
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	LD	A,(L_CFD4)
	ADD	A,A
	ADD	A,A
	ADD	A,A
	ADD	A,A
	LD	B,A
	EI
L_DA8E	CALL	ClearTile_DExy
	INC	E
	LD	HL,gettilebuf
	CALL	DrawSprite16x16_HL_DExy
	HALT
	DJNZ	L_DA8E
	LD	HL,(L_D70C)
	LD	A,(HL)
	LD	(HL),#00
	POP	BC
	POP	HL
	LD	DE,#0010
	AND	A
	SBC	HL,DE
	LD	(HL),A
	LD	(L_D70C),HL
	LD	A,(L_D70E)
	ADD	A,C
	LD	(L_D70E),A
	LD	DE,(L_D70E)
	CALL	X2Y2toxy_DE
	JP	L_D73E
;
Halter5_
	HALT
	HALT
	HALT
	HALT
	HALT
	RET
;
       DB       #01,#80,#07,#0B,#78,#B1,#C2,#C7       ;....x1BG
       DB       #DA,#C9       ;ZI
;
AnimateAppear
	LD	B,#06
	LD	HL,appearanim
L_DAD3	PUSH	BC
	PUSH	HL
	LD	DE,(curyx)
	LD	A,(HL)
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter5_
	HALT
	HALT
	HALT
	POP	HL
	POP	BC
	INC	HL
	DJNZ	L_DAD3
	CALL	countcurtileaddr
	LD	A,(HL)
	LD	DE,(curyx)
	CALL	DrawTile_A_X2Y2DE
	RET
;
appearanim       DB       #02,#16,#17,#18,#19,#1A
;
LevelExit
	LD	HL,stoptimer
	DEC	(HL)
	CALL	AnimateExit
	CALL	Setstoptimer255
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	XOR	A ;return with OK
	RET
;
AnimateExit
	LD	B,#07
	LD	HL,exitanim
L_DB1A	PUSH	BC
	PUSH	HL
	LD	DE,(curyx)
	LD	A,(HL)
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter5_
	HALT
	HALT
	HALT
	POP	HL
	POP	BC
	INC	HL
	DJNZ	L_DB1A
	RET
;
exitanim       DB       #1B,#1C,#1D,#1E,#1F,#20,#02
;
L_DB37	LD	E,#00
	LD	HL,unpackedlevel
L_DB3C	LD	B,#10
	LD	D,#00
L_DB40	LD	A,(HL)
	CP	#02
	JR	Z,BlinkLevelExit
	INC	HL
	INC	D
	DJNZ	L_DB40
	INC	E
	JR	L_DB3C
;
BlinkLevelExit
	LD	B,#08
L_DB4E	PUSH	BC
	PUSH	DE
	PUSH	DE
	LD	A,#10
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter15
	POP	DE
	LD	A,#02
	CALL	DrawTile_A_X2Y2DE
	CALL	Halter15
	POP	DE
	POP	BC
	DJNZ	L_DB4E
	RET
;
Halter15
	LD	B,#0F
L_DB69	HALT
	DJNZ	L_DB69
	RET
;
tdrakon
       DB       #16,#16,#05
       DM       "drakon"
       DB       #00
tkursor
       DB       #16,#16,#05
       DM       "kursor"
       DB       #00
;
Setstoptimer255
	;DI
	XOR	A
	DEC	A
	LD	HL,stoptimer
	LD	(HL),A
	;EI
	RET
;
GetHourglass
	LD	HL,curgametimer
	INC	(HL)
	LD	HL,curtimerlow
	LD	(HL),#01
	LD	HL,stoptimer
	LD	(HL),#00
	CALL	PrintGameTimer
	RET
;
Halter5	HALT
	HALT
	HALT
	HALT
	HALT
	RET
;
Halter	HALT
	RET
;
GO
        if EGA
        push iy
        ld de,emptypal
        OS_SETPAL
        call Halter
        call clsega
        ld e,3+0x80 ;6912+keep
        OS_SETGFX ;e=0:EGA, e=2:MC, e=3:6912, e=6:text ;+SET FOCUS ;e=-1: disable gfx (out: e=old gfxmode)
        ld de,standardpal
        OS_SETPAL
        pop iy
        ld a,(user_scr0_high) ;ok
        SETPG16K
        endif
	;DI
	IN	A,(#1F)
	CPL
	LD	(kempstonon),A
	LD	IY,L_5B00
	LD	HL,#5800
	LD	DE,#5801
	LD	BC,#02FF
	LD	(HL),L
	LDIR
	LD	SP,GAMESTACK;L_FFFF ;for game restart
	XOR	A
	;OUT	(#FE),A
	DEC	A
	LD	(stoptimer),A
	CALL	Set_L_FF32
	;CALL	SetInt
	CALL	InitArrays
	CALL	DepackSplashScreen

	if 1==0
	CALL	SlowClearScreen
	xor a
	ld d,a
	ld e,a
prtiles0
	push af
	push de
	;call DrawTile_A_X2Y2DE
        call DrawSprite_A_DExy
	pop de
        ld a,d
        add a,16
	ld d,a ;x
	jr nz,$+6
         ld a,e
         add a,16
	 ld e,a ;y
	pop af
	inc a
	cp 192
	jr nz,prtiles0
	jr $
	endif

	CALL	WaitAnyKey
L_DBD4
	CALL	SlowClearScreen
	CALL	DepackMenu
L_DBDA	CALL	WaitMenuKey;L_DBF3
	DEC	A
	JP	Z,FirstLevel
	DEC	A
	JP	Z,EnterCode
	DEC	A
	JP	Z,ShowControls
	DEC	A
	JP	Z,ShowInstructions
	DEC	A
	JP	Z,ShowAuthors
	JR	L_DBDA ;impossible?
;
CheckBreak
	 ld a,0xfe
	 in a,(0xfe)
	 rra ;CS
	 ret c
	 ld a,0x7f
	 in a,(0xfe)
	 rra ;Space
	 ret
WaitMenuKey;L_DBF3
;out: A=1..5
        ld a,(user_scr0_high) ;ok
        SETPG16K
	 call CheckBreak
	 jp nc,quiter
	LD	A,#F7
	IN	A,(#FE) ;12345
	LD	HL,BlinkMenuItem;L_DC13
	PUSH	HL
	LD	D,#01
	BIT	0,A
	RET	Z
	INC	D
	BIT	1,A
	RET	Z
	INC	D
	BIT	2,A
	RET	Z
	INC	D
	BIT	3,A
	RET	Z
	INC	D
	BIT	4,A
	RET	Z
	POP	HL
	JR	WaitMenuKey;L_DBF3
;
BlinkMenuItem;L_DC13
     ld   a,d
     push af
     dec  a
     add  a,a
     add  a,0x0F
     inc  a
     ld   b,a
     ld   hl,0x580A
     ld   de,0x0020
     and  a
     sbc  hl,de
DC24 add  hl,de
     djnz DC24
     ld   b,0x06
DC29 push bc
     push hl
     ld   a,0x47
     call DC4B
     ei
     ld   b,0x08
DC33 halt
     djnz DC33
     pop  hl
     push hl
     ld   a,0x41
     call DC4B
     ld   b,0x08
DC3F halt
     djnz DC3F
     pop  hl
     pop  bc
     djnz DC29
     call SlowClearScreen;L_B6F5
     pop  af
     ret
DC4B
     ld   b,0x0C
DC4D ld   (hl),a
     inc  l
     djnz DC4D
     ret
;
Set_L_FF32
	LD	HL,L_FF32
	LD	DE,L_61AB
	LD	(HL),#C3
	INC	HL
	LD	(HL),E
	INC	HL
	LD	(HL),D
	RET
;
FirstLevel	XOR	A
NextLevel_A	INC	A
StartLevel_A
	LD	(curlevel),A
	CALL	L_7DFA
	CALL	L_DC9E
	CALL	ShowLevelData
	CALL	WaitAnyKey
	CALL	SlowClearScreen
        
        if EGA
        push iy
        ld de,emptypal
        OS_SETPAL
        call Halter
        call clsega
        ld e,0+0x80 ;EGA+keep
        OS_SETGFX ;e=0:EGA, e=2:MC, e=3:6912, e=6:text ;+SET FOCUS ;e=-1: disable gfx (out: e=old gfxmode)
        ld de,slabpal
        OS_SETPAL
        pop iy
        ld bc,0x1880 ;b=hgt,c=wid (/2)
        ld de,panelgfx ;de=gfx
        ld hl,0x4000+((192-24)*40)+4 ;hl=scr
        call primgega
        endif
        
	CALL	UnpackLevelInfo
	CALL	UnpackLevel
	CALL	GameProcess
	PUSH	AF
        
        if EGA
        push iy
        ld de,emptypal
        OS_SETPAL
        call Halter
        call clsega
        ld e,3+0x80 ;6912+keep
        OS_SETGFX ;e=0:EGA, e=2:MC, e=3:6912, e=6:text ;+SET FOCUS ;e=-1: disable gfx (out: e=old gfxmode)
        ld de,standardpal
        OS_SETPAL
        pop iy
        ld a,(user_scr0_high) ;ok
        SETPG16K
        endif
        
        if EGA == 0
	CALL	SlowClearScreen
        endif

	POP	AF
	OR	A
	JP	M,EndOfGame
	CP	#01
	JP	Z,L_DE9E
       if 1==0
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
	DB	#00
       endif
	LD	A,(curlevel)
	CP	#37
	JP	Z,L_DFDD
	jp	NextLevel_A
;
L_DC9E	LD	A,(curlevel)
	LD	C,#00
L_DCA3	SUB	#0A
	JR	C,L_DCAA
	INC	C
	JR	L_DCA3
;
L_DCAA	ADD	A,#3A
	LD	(L_DCC0),A
	LD	A,C
	ADD	A,#30
	LD	(L_DCBF),A
	LD	HL,L_DCBC
	CALL	PrintStringHL
	RET
;
L_DCBC       DB       #16,#05,#13
L_DCBF       DM       "0"
L_DCC0       DM       "0"
;
       DB       #00
;
ShowLevelData
	LD	HL,(curlevel)
	DEC	L
	LD	H,#00
	ADD	HL,HL
	ADD	HL,HL
	LD	DE,passcodes
	ADD	HL,DE
	LD	BC,#0004
	LD	DE,L_DCE0
	LDIR
	LD	HL,L_DCDD
	CALL	PrintStringHL
	RET
;
L_DCDD       DB       #16,#07,#10
;
L_DCE0       DM       "0000"
;
       DB       #00
curlevel       DB       #00
;
passcodes
       DM       "1111"
       DM       "3627"
       DM       "5789"
       DM       "3423"
       DM       "1239"
       DM       "2763"
       DM       "4621"
       DM       "8912"
       DM       "9110"
       DM       "0012"
       DM       "1872"
       DM       "1873"
       DM       "3721"
       DM       "4921"
       DM       "7432"
       DM       "2091"
       DM       "1900"
       DM       "2000"
       DM       "3942"
       DM       "4672"
       DM       "4957"
       DM       "1956"
       DM       "1957"
       DM       "4822"
       DM       "1933"
       DM       "1764"
       DM       "1935"
       DM       "8462"
       DM       "5465"
       DM       "2245"
       DM       "8989"
       DM       "1644"
       DM       "5399"
       DM       "2198"
       DM       "2199"
       DM       "2010"
       DM       "7611"
       DM       "4621"
       DM       "7832"
       DM       "7577"
       DM       "3778"
       DM       "6567"
       DM       "9822"
       DM       "9388"
       DM       "0345"
       DM       "2567"
       DM       "2356"
       DM       "0912"
       DM       "9012"
       DM       "7433"
       DM       "3355"
       DM       "0999"
       DM       "1357"
       DM       "2468"
       DM       "3398"
       DB       #00
;
WaitAnyKey
	XOR	A
	IN	A,(#FE)
	AND	#1F
	CP	#1F
	RET	NZ
	JR	WaitAnyKey
;
UnpackLevelInfo
	LD	A,(curlevel)
	LD	DE,#0052 ;level size
	LD	HL,levels
	LD	B,A
L_DDD7	ADD	HL,DE
	DJNZ	L_DDD7
	LD	(curleveladdr),HL
	LD	HL,(curlevel)
	DEC	L
	LD	H,#00
	PUSH	HL
	ADD	HL,HL
	POP	DE
	ADD	HL,DE
	LD	DE,timeperlevel
	ADD	HL,DE
	LD	DE,tstarttime
	LD	B,#03
L_DDF0	LD	A,(HL)
	SUB	#30
	LD	(DE),A
	INC	HL
	INC	DE
	DJNZ	L_DDF0
	RET
;
timeperlevel
       DM       "400"
       DM       "440"
       DM       "480"
       DM       "520"
       DM       "560"
       DM       "370"
       DM       "240"
       DM       "185"
       DM       "320"
       DM       "220"
       DM       "250"
       DM       "200"
       DM       "240"
       DM       "225"
       DM       "260"
       DM       "210"
       DM       "225"
       DM       "360"
       DM       "280"
       DM       "250"
       DM       "210"
       DM       "200"
       DM       "220"
       DM       "210"
       DM       "200"
       DM       "440"
       DM       "280"
       DM       "250"
       DM       "320"
       DM       "200"
       DM       "240"
       DM       "360"
       DM       "240"
       DM       "280"
       DM       "320"
       DM       "240"
       DM       "260"
       DM       "230"
       DM       "300"
       DM       "360"
       DM       "220"
       DM       "360"
       DM       "320"
       DM       "400"
       DM       "360"
       DM       "320"
       DM       "280"
       DM       "275"
       DM       "240"
       DM       "170"
       DM       "200"
       DM       "250"
       DM       "150"
       DM       "200"
       DM       "200"
;
L_DE9E	JP	GO
;
EnterCode
	CALL	DepackInputLevelCodeScreen
	LD	HL,curpasscode
	LD	DE,curpasscode+1
	LD	(HL),#20
	LD	BC,#0003
	LDIR ;fill ATTRs for passcode
	CALL	PrintPassCode
	LD	B,#04
	LD	HL,curpasscode
L_DEB9	PUSH	BC
	PUSH	HL
	CALL	L_DF32
	CALL	PrintPassCode
	EI
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	POP	HL
	POP	BC
	INC	HL
	DJNZ	L_DEB9
	LD	IX,curpasscode
	LD	C,#01
	PUSH	IY
	LD	IY,passcodes
L_DEE2	LD	A,(IX+#00)
	CP	(IY+#00)
	JR	NZ,L_DF02
	LD	A,(IX+#01)
	CP	(IY+#01)
	JR	NZ,L_DF02
	LD	A,(IX+#02)
	CP	(IY+#02)
	JR	NZ,L_DF02
	LD	A,(IX+#03)
	CP	(IY+#03)
	JR	Z,L_DF13
L_DF02	INC	IY
	INC	IY
	INC	IY
	INC	IY
	LD	A,(IY+#00)
	OR	A
	JR	Z,L_DF1E
	INC	C
	JR	L_DEE2
;
L_DF13	PUSH	BC
	CALL	SlowClearScreen
	POP	BC
	POP	IY
	LD	A,C ;level
	JP	StartLevel_A
;
L_DF1E	POP	IY
	JP	L_DBD4
;
atpasscode
       DB       #16,#09,#11
curpasscode
       DM       "    "
       DB       #00
;
PrintPassCode
	LD	HL,atpasscode
	CALL	PrintStringHL
	RET
;
L_DF32
        ld a,(user_scr0_high) ;ok
        SETPG16K
	CALL	L_DF4E
	LD	A,#30
	ADD	A,D
	LD	(HL),A
L_DF39	LD	A,#F7
	IN	A,(#FE)
	AND	#1F
	CP	#1F
	JR	NZ,L_DF39
	LD	A,#EF
	IN	A,(#FE)
	AND	#1F
	CP	#1F
	JR	NZ,L_DF39
	RET
;
L_DF4E	LD	D,#00
	LD	BC,#EFFE
	IN	A,(C)
	BIT	0,A
	RET	Z
	INC	D
	LD	BC,#F7FE
	IN	A,(C)
	BIT	0,A
	RET	Z
	INC	D
	BIT	1,A
	RET	Z
	INC	D
	BIT	2,A
	RET	Z
	INC	D
	BIT	3,A
	RET	Z
	INC	D
	BIT	4,A
	RET	Z
	LD	BC,#EFFE
	IN	A,(C)
	INC	D
	BIT	4,A
	RET	Z
	INC	D
	BIT	3,A
	RET	Z
	INC	D
	BIT	2,A
	RET	Z
	INC	D
	BIT	1,A
	RET	Z
	JR	L_DF4E
;
ShowAuthors
	CALL	DepackAuthorsScreen
	CALL	WaitAnyKey
	JP	L_DBD4
;
ShowInstructions
	CALL	DepackHelp1
	CALL	WaitAnyKey
	CALL	SlowClearScreen
	CALL	DepackHelp2
	CALL	WaitAnyKey
	CALL	SlowClearScreen
	CALL	DepackHelp3
	CALL	WaitAnyKey
	CALL	SlowClearScreen
	CALL	DepackHelp4
	CALL	WaitAnyKey
	JP	L_DBD4
;
ShowControls
	CALL	DepackControlInformationScreen
	CALL	WaitAnyKey
	JP	L_DBD4
;
EndOfGame
	LD	A,#47
	CALL	L_B781
	LD	HL,tendofgame
	CALL	PrintStringHL
	CALL	WaitAnyKey
	JP	L_DBD4
;
tendofgame
       DB       #16,#08,#0B
       DM       "konec igry"
       DB       #00
;
L_DFDD	CALL	DepackCastle
	CALL	L_E02F
	LD	HL,#5800
	LD	C,#16
	CALL	L_E004
	LD	HL,#5820
	LD	C,#11
	CALL	L_E004
	LD	HL,#5840
	LD	C,#10
	CALL	L_E004
	CALL	WaitAnyKey
	CALL	SlowClearScreen
	JP	EndOfGame
;
L_E004	LD	B,#06
L_E006	PUSH	BC
	PUSH	HL
L_E008	LD	A,(HL)
	AND	#07
	LD	D,A
	INC	D
	LD	A,(HL)
	AND	#F8
	OR	D
	LD	(HL),A
	INC	HL
	DEC	C
	JR	NZ,L_E008
	POP	HL
	EI
	CALL	Halter5_
	CALL	Halter5_
	CALL	Halter5_
	POP	BC
	DJNZ	L_E006
	RET
;
L_E025	;DI
	PUSH	IY
	CALL	jphl;#006F
	POP	IY
	;EI
	RET
;
L_E02F	;DI
	LD	HL,DepackSmallDragon
	CALL	L_E025
	LD	B,#96
	;EI
L_E039	HALT
	DJNZ	L_E039
	LD	A,#01
L_E03E	PUSH	AF
	LD	HL,DepackSmallDragon
	CALL	L_E025
	POP	AF
	PUSH	AF
	LD	B,A
L_E048	HALT
	DJNZ	L_E048
	LD	HL,DepackBigDragon
	CALL	L_E025
	POP	AF
	LD	B,A
L_E053	HALT
	DJNZ	L_E053
	INC	A
	CP	#1A
	JR	NZ,L_E03E
	RET
;
        if 1==0
       DB       #7E,#EB,#A1,#C8,#79,#DD,#AE,#EA       ;~k!Hy].j
       DB       #DD,#77,#EA,#AF,#C9,#DD,#6E,#FC       ;]wj/I]n|
       DB       #DD,#66,#FD,#7D,#B4,#C8,#E9,#CD       ;]f}}4HiM
       DB       #32,#E1,#DD,#CB,#F0,#76,#C0,#AF       ;2a]Kpv@/
       DB       #C9,#CD,#04,#E1,#18,#F4,#CD,#5D       ;IM.a.tM]
       DB       #E1,#18,#EF,#DD,#7E,#F4,#DD,#BE       ;a.o]~t]>
       DB       #F3,#20,#08,#CD,#22,#E2,#3E,#20       ;s .M"b> 
       DB       #BE,#20,#11,#CD,#32,#E1,#30,#07       ;> .M2a0.
       DB       #3C,#DD,#CB,#F0,#76,#20,#17,#CD       ;<]Kpv .M
       DB       #22,#E2,#3E,#20,#77,#CD,#F1,#E1       ;"b> wMqa
       DB       #0E,#0A,#D7,#CD,#2D,#E1,#DD,#CB       ;..WM-a]K
       DB       #F0,#4E,#C8,#C3,#9A,#E1,#FE,#28       ;pNHC.a~(
       DB       #37,#C0,#DD,#46,#F8,#04,#05,#C8       ;7@]Fx..H
       DB       #CD,#A3,#E0,#3E,#27,#37,#C9,#CD       ;M#`>'7IM
       DB       #F2,#E0,#C0,#DD,#7E,#F3,#DD,#96       ;r`@]~s].
       DB       #EE,#38,#2A,#DD,#77,#F3,#18,#51       ;n8*]ws.Q
       DB       #CD,#F2,#E0,#C0,#DD,#7E,#F3,#DD       ;Mr`@]~s]
       DB       #86,#EE,#38,#19,#4F,#DD,#7E,#F4       ;.n8.O]~t
       DB       #B9,#38,#12,#79,#18,#E5,#47,#DD       ;98.y.eG]
       DB       #7E,#F7,#A7,#20,#08,#DD,#7E,#EF       ;~w' .]~o
       DB       #3D,#28,#02,#AF,#C9,#78,#A7,#C9       ;=(./Ix'I
       DB       #DD,#7E,#F4,#DD,#4E,#F3,#0C,#B9       ;]~t]Ns.9
       DB       #3E,#20,#D8,#DD,#7E,#F6,#B9,#30       ;> X]~v90
       DB       #07,#DD,#CB,#F0,#46,#3E,#23,#C0       ;.]KpF>#@
       DB       #DD,#71,#F3,#DD,#7E,#F7,#DD,#86       ;]qs]~w].
       DB       #EE,#3D,#DD,#96,#F8,#B9,#3E,#26       ;n=].x9>&
       DB       #D8,#CD,#F1,#E1,#AF,#C9,#DD,#7E       ;XMqa/I]~
       DB       #F3,#A7,#20,#04,#3E,#21,#37,#C9       ;s' .>!7I
       DB       #3D,#DD,#BE,#F5,#30,#09,#DD,#CB       ;=]>u0.]K
       DB       #F0,#46,#28,#03,#3E,#24,#C9,#F5       ;pF(.>$Iu
       DB       #DD,#7E,#F7,#DD,#86,#F8,#47,#F1       ;]~w].xGq
       DB       #B8,#3E,#27,#DD,#35,#F3,#D8,#18       ;8>']5sX.
       DB       #D0,#CD,#37,#E0,#78,#A7,#C8,#05       ;PM7`x'H.
       DB       #78,#DD,#BE,#F4,#30,#1E,#DD,#CB       ;x]>t0.]K
       DB       #F0,#46,#28,#05,#DD,#BE,#F6,#30       ;pF(.]>v0
       DB       #17,#CD,#1D,#E2,#5D,#54,#2B,#CD       ;.M.b]T+M
       DB       #90,#E1,#C8,#ED,#B8,#DD,#CB,#F0       ;.aHm8]Kp
       DB       #FE,#23,#18,#21,#3E,#29,#37,#C9       ;~#.!>)7I
       DB       #3E,#2A,#37,#C9,#DD,#7E,#F4,#DD       ;>*7I]~t]
       DB       #96,#F3,#4F,#06,#00,#C9,#CD,#90       ;.sO..IM.
       DB       #E1,#C8,#CD,#22,#E2,#06,#00,#5D       ;aHM"b..]
       DB       #54,#23,#ED,#B0,#2B,#36,#20,#CD       ;T#m0+6 M
       DB       #34,#E2,#DD,#86,#F7,#DD,#96,#F3       ;4b].w].s
       DB       #C8,#CD,#26,#E2,#47,#DD,#7E,#F3       ;HM&bG]~s
       DB       #F5,#E5,#CD,#F1,#E1,#E1,#7E,#0E       ;ueMqaa~.
       DB       #0A,#D7,#23,#DD,#34,#F3,#10,#F1       ;.W#]4s.q
       DB       #F1,#DD,#77,#F3,#AF,#C9,#3E,#20       ;q]ws/I> 
       DB       #DD,#CB,#F0,#AE,#A7,#C4,#DE,#E1       ;]Kp.'D^a
       DB       #18,#CD,#5F,#CD,#90,#E1,#7B,#CD       ;.M_M.a{M
       DB       #22,#E2,#42,#77,#0C,#0D,#C8,#5D       ;"bBw..H]
       DB       #54,#13,#ED,#B0,#C9,#F5,#DD,#7E       ;T.m0Iu]~
       DB       #F3,#DD,#96,#F7,#26,#00,#DD,#6E       ;s].w&.]n
       DB       #EE,#BD,#38,#04,#95,#24,#18,#F9       ;n=8..$.y
       DB       #DD,#6E,#EC,#85,#6F,#DD,#7E,#ED       ;]nl.o]~m
       DB       #84,#67,#0E,#0C,#D7,#F1,#C9,#DD       ;.g..WqI]
       DB       #46,#FA,#04,#05,#28,#0F,#05,#18       ;Fz..(...
       DB       #0C,#DD,#46,#F4,#18,#07,#DD,#CB       ;.]Ft..]K
       DB       #F0,#FE,#DD,#46,#F3,#DD,#6E,#F1       ;p~]Fs]nq
       DB       #DD,#66,#F2,#58,#16,#00,#19,#C9       ;]frX...I
       DB       #AF,#DD,#46,#EF,#DD,#86,#EE,#10       ;/]Fo].n.
       DB       #FB,#C9,#30,#10,#E5,#EB,#5E,#23       ;{I0.ek^#
       DB       #56,#D5,#23,#5E,#23,#56,#D5,#D9       ;VU#^#VUY
       DB       #D1,#D9,#D1,#E1,#F5,#05,#28,#09       ;QYQau.(.
       DB       #04,#28,#06,#F1,#48,#47,#C3,#35       ;.(.qHGC5
       DB       #E3,#F1,#18,#4F,#B7,#CC,#9E,#E2       ;cq.O7L.b
       DB       #D8,#11,#B1,#E2,#D5,#11,#B3,#E2       ;X.1bU.3b
       DB       #4F,#18,#04,#23,#0D,#28,#3C,#7E       ;O..#.(<~
       DB       #FE,#20,#28,#F7,#EB,#C5,#06,#0D       ;~ (wkE..
       DB       #2B,#23,#BE,#28,#0D,#10,#FA,#C1       ;+#>(..zA
       DB       #78,#41,#4F,#B7,#20,#36,#0E,#0A       ;xAO7 6..
       DB       #18,#32,#23,#CB,#7E,#28,#FB,#0D       ;.2#K~({.
       DB       #28,#19,#41,#4E,#CB,#B9,#13,#E1       ;(.ANK9.a
       DB       #18,#22,#E5,#1E,#FF,#3E,#0D,#BE       ;."e..>.>
       DB       #20,#04,#E1,#7B,#2F,#C9,#23,#1D       ; .a{/I#.
       DB       #20,#F5,#E1,#37,#C9,#D9,#C9,#23       ; ua7IYI#
       DB       #48,#68,#90,#2E,#64,#8A,#25,#62       ;Hh..d.%b
       DB       #82,#4F,#6F,#88,#ED,#62,#E5,#D9       ;.Oo.mbeY
       DB       #E1,#D9,#1A,#FE,#20,#28,#1D,#13       ;aY.~ (..
       DB       #D5,#C5,#C5,#11,#FA,#E2,#EB,#06       ;UEE.zbk.
       DB       #FF,#0C,#04,#0D,#28,#17,#BE,#23       ;....(.>#
       DB       #20,#F8,#68,#C1,#CD,#0A,#E3,#C1       ; xhAM.cA
       DB       #D1,#3E,#01,#D8,#10,#DC,#D5,#C1       ;Q>.X.\UA
       DB       #D9,#E5,#D9,#D1,#C9,#AF,#37,#C1       ;YeYQI/7A
       DB       #C1,#EB,#C1,#0B,#18,#F2,#30,#31       ;AkA..r01
       DB       #32,#33,#34,#35,#36,#37,#38,#39       ;23456789
       DB       #41,#42,#43,#44,#45,#46,#AF,#67       ;ABCDEF/g
       DB       #D9,#57,#5F,#EB,#D9,#CB,#39,#30       ;YW_kYK90
       DB       #08,#19,#D9,#ED,#5A,#D9,#D8,#AF       ;..YmZYX/
       DB       #B1,#C8,#CD,#23,#E3,#18,#EE,#CB       ;1HM#c.nK
       DB       #13,#CB,#12,#D9,#CB,#13,#CB,#12       ;.K.YK.K.
       DB       #D9,#C9,#7A,#B3,#D9,#B2,#B3,#D9       ;YIz3Y23Y
       DB       #C9,#38,#05,#D9,#11,#00,#00,#D9       ;I8.Y...Y
       DB       #78,#3D,#85,#6F,#30,#01,#24,#CD       ;x=.o0.$M
       DB       #2E,#E3,#28,#2A,#C5,#CD,#2E,#E3       ;.c(*EM.c
       DB       #28,#19,#06,#21,#AF,#17,#91,#30       ;(..!/..0
       DB       #01,#81,#3F,#CD,#23,#E3,#10,#F5       ;..?M#c.u
       DB       #E5,#21,#FA,#E2,#4F,#09,#7E,#E1       ;e!zbO.~a
       DB       #B7,#77,#2B,#C1,#28,#0D,#10,#DC       ;7w+A(..\
       DB       #CD,#2E,#E3,#C8,#37,#C9,#36,#30       ;M.cH7I60
       DB       #05,#C8,#2B,#36,#20,#2B,#10,#FB       ;.H+6 +.{
       DB       #C9,#DD,#7E,#FE,#32,#9E,#E4,#22       ;I]~~2.d"
       DB       #B5,#E4,#DD,#46,#FF,#48,#3E,#10       ;5d]F.H>.
       DB       #0F,#CB,#09,#30,#FB,#32,#F5,#E3       ;.K.0{2uc
       DB       #32,#52,#E4,#48,#DD,#66,#02,#25       ;2RdH]f.%
       DB       #25,#DD,#56,#01,#14,#DD,#5E,#00       ;%]V..]^.
       DB       #1C,#7C,#32,#40,#E4,#07,#07,#07       ;.|2@d...
       DB       #90,#32,#F8,#E3,#32,#55,#E4,#DD       ;.2xc2Ud]
       DB       #7E,#03,#3D,#3D,#32,#A8,#E4,#EB       ;~.==2(dk
       DB       #E5,#CD,#E4,#E3,#22,#FB,#E3,#CD       ;eMdc"{cM
       DB       #42,#E4,#10,#FB,#22,#FE,#E3,#E1       ;Bd.{"~ca
       DB       #7C,#82,#67,#CD,#E4,#E3,#CD,#8E       ;|.gMdcM.
       DB       #E4,#25,#22,#5B,#E4,#41,#CD,#8E       ;d%"[dAM.
       DB       #E4,#25,#10,#FA,#22,#58,#E4,#C9       ;d%.z"XdI
       DB       #7C,#0F,#0F,#0F,#AD,#E6,#E0,#AD       ;|...-f`-
       DB       #6F,#7C,#E6,#18,#F6,#40,#67,#C9       ;o|f.v@gI
       DB       #06,#01,#C5,#3E,#90,#08,#11,#91       ;..E>....
       DB       #40,#21,#B1,#40,#06,#00,#CD,#A7       ;@!1@..M'
       DB       #E4,#28,#0A,#08,#CD,#42,#E4,#EB       ;d(..MBdk
       DB       #CD,#42,#E4,#18,#F1,#CD,#42,#E4       ;MBd.qMBd
       DB       #CD,#9C,#E4,#10,#DD,#ED,#5B,#FB       ;M.d.]m[{
       DB       #E3,#CD,#32,#E4,#21,#20,#00,#19       ;cM2d! ..
       DB       #0D,#C8,#C5,#E5,#7E,#12,#1C,#2C       ;.HEe~..,
       DB       #10,#FA,#D1,#C1,#18,#EE,#7A,#1F       ;.zQA.nz.
       DB       #1F,#1F,#E6,#03,#F6,#58,#57,#ED       ;..f.vXWm
       DB       #4B,#A7,#E4,#0E,#13,#C9,#24,#3E       ;K'd..I$>
       DB       #07,#A4,#C0,#3E,#20,#85,#6F,#D8       ;.$@> .oX
       DB       #7C,#D6,#08,#67,#C9,#06,#01,#C5       ;|V.gI..E
       DB       #3E,#90,#08,#21,#B1,#57,#11,#D1       ;>..!1W.Q
       DB       #57,#06,#00,#CD,#A7,#E4,#28,#0C       ;W..M'd(.
       DB       #08,#CD,#8E,#E4,#25,#EB,#CD,#8E       ;.M.d%kM.
       DB       #E4,#25,#18,#EF,#CD,#9C,#E4,#10       ;d%.oM.d.
       DB       #DE,#ED,#5B,#5B,#E4,#CD,#32,#E4       ;^m[[dM2d
       DB       #21,#E0,#FF,#19,#0D,#C8,#C5,#E5       ;!`...HEe
       DB       #7E,#12,#1C,#2C,#10,#FA,#D1,#C1       ;~..,.zQA
       DB       #18,#EE,#3E,#07,#A4,#C0,#7D,#D6       ;.n>.$@}V
       DB       #20,#6F,#D8,#7C,#C6,#08,#67,#C9       ; oX|F.gI
       DB       #21,#01,#00,#2B,#7C,#B5,#20,#FB       ;!..+|5 {
       DB       #E1,#C1,#E9,#0E,#0E,#79,#08,#FE       ;aAi..y.~
       DB       #09,#D5,#E5,#ED,#B0,#30,#13,#08       ;.Uem00..
       DB       #11,#00,#00,#2B,#72,#3D,#28,#09       ;...+r=(.
       DB       #3D,#2B,#28,#04,#36,#00,#18,#F8       ;=+(.6..x
       DB       #73,#08,#D1,#E1,#3D,#C9,#25,#E6       ;s.Qa=I%f
       DB       #08,#E6,#34,#E6,#37,#E6,#F1,#EA       ;.f4f7fqj
       DB       #71,#E6,#E0,#E9,#22,#E5,#53,#E6       ;qf`i"eSf
       DB       #5B,#E6,#A2,#E5,#7C,#E6,#79,#E6       ;[f"e|fyf
       DB       #F4,#E4,#46,#E9,#E0,#E5,#6C,#E7       ;tdFi`elg
       DB       #AC,#E8,#12,#E8,#62,#E8,#20,#ED       ;,h.hbh m
       DB       #0E,#16,#D7,#38,#19,#D9,#11,#04       ;..W8.Y..
       DB       #00,#19,#46,#FE,#18,#38,#0F,#FE       ;..F~.8.~
       DB       #D8,#30,#0B,#0E,#17,#D7,#78,#A7       ;X0...Wx'
       DB       #20,#E6,#32,#D5,#E6,#C9,#3E,#8A       ; f2UfI>.
       DB       #37,#C9,#E5,#2A,#A0,#E6,#37,#ED       ;7Ie* f7m
       DB       #52,#E1,#D0,#12,#1B,#C9,#F5,#0E       ;RaP..Iu.
       DB       #33,#D7,#D9,#22,#9C,#E5,#D9,#F1       ;3WY".eYq
       DB       #B7,#4B,#42,#28,#05,#0E,#16,#D7       ;7KB(...W
       DB       #D8,#D9,#0B,#22,#A0,#E6,#09,#36       ;XY." f.6
       DB       #5C,#22,#7F,#E5,#2B,#EB,#D5,#0E       ;\".e+kU.
       DB       #35,#D7,#D9,#D1,#01,#20,#00,#09       ;5WYQ. ..
       DB       #7E,#3C,#28,#20,#0E,#08,#09,#41       ;~<( ...A
       DB       #2B,#7E,#FE,#20,#C4,#16,#E5,#10       ;+~~ D.e.
       DB       #F7,#3E,#5C,#CD,#16,#E5,#0E,#0C       ;w>\M.e..
       DB       #09,#D5,#5E,#23,#56,#0E,#21,#D7       ;.U^#V.!W
       DB       #D1,#D8,#18,#D2,#13,#3E,#3A,#CD       ;QX.R.>:M
       DB       #16,#E5,#0E,#33,#D7,#C6,#41,#CD       ;.e.3WFAM
       DB       #16,#E5,#21,#10,#A5,#B7,#ED,#52       ;.e!.%7mR
       DB       #4D,#44,#2A,#A0,#E6,#13,#EB,#ED       ;MD* f.km
       DB       #52,#19,#28,#0B,#ED,#B0,#ED,#52       ;R.(.m0mR
       DB       #45,#EB,#36,#20,#23,#10,#FB,#11       ;Ek6 #.{.
       DB       #44,#0B,#0E,#21,#D7,#C9,#CB,#AF       ;D..!WIK/
       DB       #21,#87,#E6,#01,#12,#00,#ED,#B1       ;!.f...m1
       DB       #C0,#CB,#39,#79,#FE,#06,#28,#1A       ;@K9y~.(.
       DB       #FE,#08,#28,#0F,#FE,#07,#28,#05       ;~.(.~.(.
       DB       #1E,#01,#AF,#79,#C9,#CD,#D5,#E5       ;../yIMUe
       DB       #4D,#18,#F5,#CD,#D5,#E5,#1E,#00       ;M.uMUe..
       DB       #18,#F0,#CD,#D5,#E5,#4A,#C3,#BC       ;.pMUeJC<
       DB       #E5,#0E,#10,#D7,#D9,#2B,#56,#2B       ;e..WY+V+
       DB       #4E,#2B,#6E,#C9,#06,#08,#E5,#7E       ;N+nI..e~
       DB       #FE,#20,#28,#05,#12,#13,#23,#10       ;~ (...#.
       DB       #F6,#3E,#2E,#12,#13,#E1,#01,#08       ;v>...a..
       DB       #00,#09,#01,#03,#00,#ED,#B0,#3E       ;.....m0>
       DB       #0D,#12,#D9,#AF,#C9,#CD,#58,#EB       ;..Y/IMXk
       DB       #38,#02,#28,#09,#F5,#CD,#DF,#EC       ;8.(.uM_l
       DB       #C1,#D8,#C5,#F1,#C9,#3A,#AC,#E6       ;AXEqI:,f
       DB       #47,#0E,#1C,#D7,#38,#EE,#ED,#5B       ;G..W8nm[
       DB       #AD,#E6,#0E,#21,#D7,#38,#E5,#AF       ;-f.!W8e/
       DB       #C9,#CD,#01,#E6,#D8,#C0,#21,#AF       ;IM.fX@!/
       DB       #E6,#0E,#25,#D7,#38,#D6,#AF,#C9       ;f.%W8V/I
       DB       #22,#D1,#E6,#CD,#01,#E6,#D8,#20       ;"QfM.fX 
       DB       #11,#AF,#21,#BB,#E6,#CB,#6E,#28       ;./!;fKn(
       DB       #09,#AF,#3A,#B9,#E6,#2A,#B7,#E6       ;./:9f*7f
       DB       #D9,#C9,#21,#AF,#E6,#D9,#C9,#CD       ;YI!/fYIM
       DB       #5B,#E6,#D8,#AF,#C3,#F1,#EA,#11       ;[fX/Cqj.
       DB       #D6,#E6,#ED,#53,#D1,#E6,#06,#80       ;VfmSQf..
       DB       #7E,#FE,#0D,#12,#C8,#13,#23,#10       ;~~..H.#.
       DB       #F7,#3E,#8B,#37,#C9,#21,#D6,#E6       ;w>.7I!Vf
       DB       #11,#A6,#E6,#D9,#C9,#2A,#D1,#E6       ;.&fYI*Qf
       DB       #3E,#10,#CD,#9E,#EB,#D8,#CC,#CE       ;>.M.kXLN
       DB       #EC,#18,#B3,#51,#51,#54,#92,#53       ;l.3QQT.S
       DB       #53,#46,#94,#45,#85,#44,#84,#43       ;SF.E.D.C
       DB       #91,#42,#82,#41,#80,#63,#6F,#6D       ;.B.A.com
       DB       #2A,#2E,#2A,#0D,#D9,#A4,#00,#19       ;*.*.Y$..
       DB       #BF,#E6,#00,#44,#0B,#FF,#20,#08       ;?f.D.. .
       DB       #00,#44,#0B,#73,#6C,#61,#62,#61       ;.D.slaba
       DB       #67,#65,#20,#63,#6F,#6D,#0D,#04       ;ge com..
       DB       #00,#D7,#E6,#51,#3A,#65,#78,#74       ;.WfQ:ext
       DB       #65,#6E,#74,#2E,#74,#78,#74,#0D       ;ent.txt.
       DB       #00,#00,#44,#0B,#01,#E6,#E6,#4B       ;..D..ffK
       DB       #1B,#1D,#0D,#08,#00,#44,#0B,#73       ;.....D.s
       DB       #6C,#61,#62,#61,#67,#65,#20,#63       ;labage c
       DB       #6F,#6D,#0D,#5C,#73,#68,#65,#6C       ;om.\shel
       DB       #68,#65,#6C,#70,#2E,#68,#6C,#70       ;help.hlp
       DB       #0D,#32,#38,#2E,#62,#61,#74,#20       ;.28.bat 
       DB       #54,#3A,#61,#75,#74,#6F,#65,#78       ;T:autoex
       DB       #65,#63,#2E,#62,#61,#74,#0D,#20       ;ec.bat. 
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#20,#20,#20,#20,#20,#20,#20       ;        
       DB       #20,#00,#14,#00,#43,#41,#54,#0D       ; ...CAT.
       DB       #45,#52,#52,#0D,#4C,#5F,#53,#0D       ;ERR.L_S.
       DB       #4C,#5F,#51,#0D,#4C,#5F,#54,#0D       ;L_Q.L_T.
       DB       #4F,#06,#08,#CD,#9D,#E7,#38,#5F       ;O..M.g8_
       DB       #CD,#83,#E7,#D8,#06,#03,#CB,#69       ;M.gX..Ki
       DB       #20,#18,#CD,#9D,#E7,#38,#50,#CD       ; .M.g8PM
       DB       #9D,#E7,#38,#0E,#C5,#E5,#CD,#B1       ;.g8.EeM1
       DB       #E7,#E1,#C1,#D8,#77,#23,#10,#EF       ;gaAXw#.o
       DB       #AF,#C9,#36,#20,#23,#10,#FB,#AF       ;/I6 #.{/
       DB       #C9,#7E,#FE,#21,#C9,#23,#24,#2D       ;I~~!I#$-
       DB       #26,#5F,#60,#2B,#3D,#30,#3A,#41       ;&_`+=0:A
       DB       #5B,#61,#7B,#80,#A0,#06,#08,#21       ;[a{. ..!
       DB       #A1,#E7,#BE,#C8,#23,#10,#FB,#06       ;!g>H#.{.
       DB       #04,#BE,#38,#13,#23,#BE,#38,#13       ;.>8.#>8.
       DB       #23,#10,#F6,#FE,#B0,#38,#1B,#FE       ;#.v~08.~
       DB       #E0,#38,#04,#FE,#F0,#38,#0D,#3E       ;`8.~p8.>
       DB       #1F,#37,#C9,#FE,#61,#38,#11,#FE       ;.7I~a8.~
       DB       #7B,#38,#07,#C9,#CB,#69,#28,#08       ;{8.IKi(.
       DB       #D6,#30,#CB,#69,#28,#02,#D6,#20       ;V0Ki(.V 
       DB       #A7,#C9,#14,#00,#72,#65,#73,#0D       ;'I..res.
       DB       #6B,#65,#79,#0D,#74,#79,#70,#0D       ;key.typ.
       DB       #6C,#70,#72,#0D,#62,#6C,#6B,#0D       ;lpr.blk.
       DB       #D8,#10,#E8,#08,#F0,#08,#F0,#08       ;X.h.p.p.
       DB       #F8,#08,#62,#61,#74,#20,#2A,#D1       ;x.bat *Q
       DB       #E6,#06,#80,#7E,#FE,#20,#20,#06       ;f..~~  .
       DB       #23,#10,#F8,#F6,#FF,#C9,#FE,#21       ;#.xv.I~!
       DB       #38,#F9,#CD,#70,#E8,#D0,#FE,#25       ;8yMphP~%
       DB       #28,#F1,#37,#C9,#23,#CD,#70,#E8       ;(q7I#Mph
       DB       #CD,#EB,#EA,#E1,#D8,#C0,#3E,#00       ;MkjaX@>.
       DB       #B7,#C0,#D9,#11,#04,#00,#19,#5E       ;7@Y....^
       DB       #23,#66,#6B,#23,#23,#5E,#23,#56       ;#fk##^#V
       DB       #23,#7B,#B2,#28,#01,#EB,#D1,#D1       ;#{2(.kQQ
       DB       #C1,#DD,#E1,#E3,#F1,#33,#33,#33       ;A]acq333
       DB       #33,#33,#33,#F5,#AF,#C9,#FE,#D8       ;333u/I~X
       DB       #38,#74,#FE,#E9,#30,#70,#0E,#16       ;8t~i0p..
       DB       #D7,#D8,#18,#CE,#0E,#FF,#11,#AF       ;WX.N.../
       DB       #E6,#D5,#7E,#FE,#21,#30,#07,#22       ;fU~~!0."
       DB       #D1,#E6,#0C,#21,#0E,#E8,#C5,#CD       ;Qf.!.hEM
       DB       #E0,#E9,#C1,#0C,#20,#03,#22,#D1       ;`iA. ."Q
       DB       #E6,#21,#B7,#E6,#11,#EE,#E7,#3E       ;f!7f.ng>
       DB       #20,#BE,#3E,#00,#C4,#46,#E9,#D1       ; >>.DFiQ
       DB       #C0,#32,#3B,#E8,#87,#21,#04,#E8       ;@2;h.!.h
       DB       #4F,#06,#00,#09,#7E,#23,#46,#EB       ;O...~#Fk
       DB       #4F,#C5,#E5,#E5,#79,#0E,#16,#D7       ;OEeey..W
       DB       #38,#19,#D9,#D1,#E5,#01,#0A,#00       ;8.YQe...
       DB       #09,#06,#08,#1A,#BE,#20,#11,#23       ;....> .#
       DB       #13,#10,#F8,#D9,#E1,#D1,#C1,#D8       ;..xYaQAX
       DB       #79,#D9,#C9,#FE,#7D,#37,#20,#F4       ;yYI~}7 t
       DB       #E1,#E1,#C1,#0C,#10,#D3,#3E,#25       ;aaA..S>%
       DB       #37,#C9,#21,#AF,#E6,#11,#56,#E7       ;7I!/f.Vg
       DB       #CD,#46,#E9,#C0,#B7,#28,#3C,#3D       ;MFi@7(<=
       DB       #28,#28,#47,#0E,#10,#D7,#C5,#D9       ;((G..WEY
       DB       #C1,#2B,#10,#FD,#CD,#06,#E9,#D8       ;A+.}M.iX
       DB       #E5,#CD,#A2,#E5,#E1,#20,#0D,#77       ;eM"ea .w
       DB       #AF,#C9,#E5,#CD,#37,#E6,#E1,#D8       ;/IeM7faX
       DB       #20,#02,#B7,#C0,#0E,#B1,#D1,#C3       ; .7@.1QC
       DB       #DA,#EC,#CD,#06,#E9,#D8,#D6,#31       ;ZlM.iXV1
       DB       #28,#04,#3C,#20,#EF,#3D,#32,#CC       ;(.< o=2L
       DB       #E6,#18,#DD,#CD,#37,#E6,#D8,#20       ;f.]M7fX 
       DB       #E3,#B7,#20,#E0,#3D,#D9,#BE,#0E       ;c7 `=Y>.
       DB       #AF,#20,#DB,#2B,#11,#A9,#E6,#12       ;/ [+.)f.
       DB       #1B,#01,#03,#00,#ED,#B8,#AF,#3E       ;....m8/>
       DB       #F3,#C9,#DD,#21,#01,#00,#3E,#20       ;sI]!..> 
       DB       #2B,#23,#BE,#28,#FC,#3E,#40,#BE       ;+#>(|>@>
       DB       #30,#2D,#08,#EB,#4E,#23,#46,#23       ;0-.kN#F#
       DB       #1A,#08,#D5,#08,#ED,#A1,#E2,#82       ;..U.m!b.
       DB       #E9,#20,#0B,#13,#1A,#08,#BE,#38       ;i ....>8
       DB       #F2,#08,#FE,#41,#38,#14,#DD,#23       ;r.~A8.]#
       DB       #D1,#1A,#08,#BE,#ED,#A1,#E2,#81       ;Q..>m!b.
       DB       #E9,#38,#F8,#18,#DD,#D5,#D1,#F6       ;i8x.]UQv
       DB       #FF,#C9,#DD,#45,#05,#EB,#F1,#AF       ;.I]E.kq/
       DB       #78,#D9,#C9,#CB,#4F,#C0,#CB,#47       ;xYIKO@KG
       DB       #20,#44,#CD,#CE,#EC,#D8,#C0,#CD       ; DMNlX@M
       DB       #08,#E6,#D4,#DE,#E8,#D8,#D1,#CA       ;.fT^hXQJ
       DB       #EB,#EA,#D5,#3A,#A3,#E6,#B7,#28       ;kjU:#f7(
       DB       #2D,#0E,#16,#D7,#D9,#22,#A0,#E6       ;-..WY" f
       DB       #3E,#40,#CD,#9E,#EB,#D8,#22,#A0       ;>@M.kX" 
       DB       #E6,#CD,#CE,#EC,#20,#0A,#21,#D6       ;fMNl .!V
       DB       #E6,#3E,#06,#CD,#9E,#EB,#D8,#C8       ;f>.M.kXH
       DB       #2A,#A0,#E6,#7E,#23,#FE,#0D,#20       ;* f~#~. 
       DB       #FA,#7E,#FE,#03,#20,#DA,#C3,#D8       ;z~~. ZCX
       DB       #EC,#11,#AF,#E6,#AF,#32,#A2,#E6       ;l./f/2"f
       DB       #0E,#0F,#7E,#2B,#41,#FE,#0D,#28       ;..~+A~.(
       DB       #15,#FE,#5C,#28,#11,#FE,#20,#28       ;.~\(.~ (
       DB       #0D,#23,#FE,#2A,#28,#12,#FE,#2E       ;.#~*(.~.
       DB       #20,#08,#CB,#61,#20,#17,#3E,#20       ; .Ka .> 
       DB       #18,#0B,#06,#08,#FE,#3F,#20,#05       ;....~? .
       DB       #3E,#FF,#32,#A2,#E6,#12,#13,#05       ;>.2"f...
       DB       #0D,#CB,#58,#20,#F8,#23,#CB,#59       ;.KX x#KY
       DB       #20,#C8,#CB,#61,#0E,#1A,#28,#C2       ; HKa..(B
       DB       #3A,#A2,#E6,#B7,#C8,#37,#C9,#CD       ;:"f7H7IM
       DB       #35,#EA,#E1,#D8,#C0,#E5,#C3,#DF       ;5jaX@eC_
       DB       #EC,#E5,#2A,#A4,#E6,#22,#D1,#E6       ;le*$f"Qf
       DB       #CD,#25,#E6,#E1,#D8,#C0,#11,#AF       ;M%faX@./
       DB       #E6,#01,#0B,#00,#ED,#B0,#7E,#CB       ;f...m0~K
       DB       #6F,#C0,#21,#A6,#E6,#11,#AC,#E6       ;o@!&f.,f
       DB       #01,#03,#00,#ED,#B0,#C5,#D1,#ED       ;...m0EQm
       DB       #53,#BB,#E6,#0E,#2D,#D7,#D8,#D9       ;S;f.-WXY
       DB       #EB,#0E,#00,#1A,#FE,#20,#20,#05       ;k...~  .
       DB       #CD,#BB,#EA,#18,#F7,#21,#B7,#E6       ;M;j.w!7f
       DB       #06,#03,#BE,#20,#09,#05,#28,#15       ;..> ..(.
       DB       #CD,#BB,#EA,#23,#18,#F4,#CD,#B8       ;M;j#.tM8
       DB       #EA,#20,#FB,#CD,#BB,#EA,#FE,#03       ;j {M;j~.
       DB       #CA,#D6,#EA,#18,#D7,#CD,#BB,#EA       ;JVj.WM;j
       DB       #FE,#3A,#20,#EA,#21,#D6,#E6,#CD       ;~: j!VfM
       DB       #BB,#EA,#FE,#20,#28,#F9,#06,#6E       ;;j~ (y.n
       DB       #77,#CD,#B8,#EA,#28,#03,#23,#20       ;wM8j(.# 
       DB       #F7,#11,#AA,#E6,#01,#11,#00,#EB       ;w.*f...k
       DB       #ED,#B0,#AF,#C9,#FE,#0D,#C8,#13       ;m0/I~.H.
       DB       #0D,#1A,#C0,#E5,#C5,#ED,#5B,#BB       ;..@eEm[;
       DB       #E6,#13,#ED,#53,#BB,#E6,#0E,#2D       ;f.mS;f.-
       DB       #D7,#D9,#C1,#EB,#E1,#38,#05,#1A       ;WYAka8..
       DB       #0E,#00,#B7,#C9,#E1,#C9,#0E,#35       ;..7IaI.5
       DB       #D7,#D9,#2B,#7E,#32,#A9,#E6,#D9       ;WY+~2)fY
       DB       #C9,#CD,#D8,#EC,#CD,#08,#E6,#21       ;IMXlM.f!
       DB       #D6,#E6,#36,#0D,#C9,#A7,#20,#03       ;Vf6.I' .
       DB       #11,#BF,#E6,#ED,#53,#A4,#E6,#CD       ;.?fmS$fM
       DB       #DA,#EA,#CD,#78,#EB,#38,#E5,#CC       ;ZjMxk8eL
       DB       #CE,#EC,#38,#E0,#CD,#EB,#EA,#20       ;Nl8`Mkj 
       DB       #DB,#21,#99,#E6,#11,#B7,#E6,#06       ;[!.f.7f.
       DB       #03,#1A,#BE,#20,#CC,#23,#13,#10       ;..> L#..
       DB       #F8,#0E,#35,#D7,#D9,#01,#0F,#00       ;x.5WY...
       DB       #09,#56,#2B,#5E,#2B,#46,#2B,#6E       ;.V+^+F+n
       DB       #60,#E5,#DD,#E1,#19,#D5,#ED,#5B       ;`e]a.Um[
       DB       #25,#F8,#EB,#ED,#52,#3E,#82,#D1       ;%xkmR>.Q
       DB       #38,#AA,#AF,#67,#6F,#0E,#29,#D7       ;8*/go.)W
       DB       #38,#A2,#DD,#E5,#DD,#21,#CD,#E6       ;8"]e]!Mf
       DB       #AF,#0E,#36,#D7,#CD,#DF,#EC,#E1       ;/.6WM_la
       DB       #D8,#C3,#52,#E8,#CD,#DA,#EA,#CD       ;XCRhMZjM
       DB       #C9,#EC,#CD,#B9,#EC,#2A,#D1,#E6       ;IlM9l*Qf
       DB       #AF,#CD,#9E,#EB,#38,#03,#CC,#CE       ;/M.k8.LN
       DB       #EC,#C3,#E8,#EA,#7E,#FE,#20,#23       ;lChj~~ #
       DB       #28,#FA,#2B,#C9,#E5,#CD,#C9,#EC       ;(z+IeMIl
       DB       #CD,#B9,#EC,#3A,#D6,#E6,#E1,#FE       ;M9l:Vfa~
       DB       #0D,#CC,#2B,#EA,#21,#D6,#E6,#CD       ;.L+j!VfM
       DB       #70,#EB,#FE,#40,#CA,#30,#E8,#FE       ;pk~@J0h~
       DB       #3B,#CA,#D6,#EA,#FE,#2A,#28,#F9       ;;JVj~*(y
       DB       #3E,#04,#22,#BD,#E6,#32,#BB,#E6       ;>."=f2;f
       DB       #CD,#70,#EB,#FE,#0D,#28,#EA,#FE       ;Mpk~.(j~
       DB       #2F,#CA,#EF,#EC,#FE,#08,#CA,#7E       ;/Jol~.J~
       DB       #EC,#23,#7E,#2B,#FE,#3A,#7E,#20       ;l#~+~:~ 
       DB       #33,#E5,#CD,#A2,#E5,#E1,#20,#2C       ;3eM"ea ,
       DB       #47,#7B,#B7,#20,#1F,#78,#BA,#28       ;G{7 .x:(
       DB       #1B,#3A,#BB,#E6,#CB,#7F,#CB,#BF       ;.:;fK.K?
       DB       #28,#08,#32,#BB,#E6,#3E,#53,#E5       ;(.2;f>Se
       DB       #18,#E0,#CB,#FF,#32,#BB,#E6,#CD       ;.`K.2;fM
       DB       #9D,#EC,#38,#E5,#E5,#CD,#B0,#EC       ;.l8eeM0l
       DB       #E1,#D8,#23,#23,#7E,#FE,#5C,#20       ;aX##~~\ 
       DB       #01,#23,#CD,#DD,#E9,#E5,#3A,#BB       ;.#M]ie:;
       DB       #E6,#CB,#57,#28,#1B,#7E,#FE,#0D       ;fKW(.~~.
       DB       #28,#04,#FE,#20,#20,#12,#21,#99       ;(.~  .!.
       DB       #E6,#11,#B7,#E6,#EB,#3E,#20,#BE       ;f.7fk> >
       DB       #20,#06,#EB,#01,#03,#00,#ED,#B0       ; .k...m0
       DB       #21,#AF,#E6,#0E,#25,#D7,#E1,#38       ;!/f.%Wa8
       DB       #12,#CB,#6F,#C8,#E5,#CD,#B4,#EC       ;.KoHeM4l
       DB       #E1,#7E,#FE,#0D,#20,#BE,#CD,#DD       ;a~~. >M]
       DB       #E9,#18,#06,#FE,#51,#28,#02,#37       ;i..~Q(.7
       DB       #C9,#3A,#BB,#E6,#CB,#7F,#28,#20       ;I:;fK.( 
       DB       #CB,#77,#20,#06,#2A,#BD,#E6,#C3       ;Kw .*=fC
       DB       #A4,#EB,#CD,#D1,#EC,#20,#0A,#21       ;$kMQl .!
       DB       #D6,#E6,#3E,#06,#CD,#A1,#EB,#D8       ;Vf>.M!kX
       DB       #C8,#3E,#80,#32,#BB,#E6,#18,#E4       ;H>.2;f.d
       DB       #3A,#BB,#E6,#CB,#57,#C2,#8F,#E9       ;:;fKWB.i
       DB       #11,#AF,#E6,#1A,#FE,#20,#20,#08       ;./f.~  .
       DB       #E5,#21,#9C,#E6,#CD,#E0,#E9,#E1       ;e!.fM`ia
       DB       #AF,#C9,#23,#11,#AC,#E6,#01,#0E       ;/I#.,f..
       DB       #00,#ED,#B0,#E5,#CD,#DF,#EC,#E1       ;.m0eM_la
       DB       #D8,#E5,#21,#AF,#E6,#0E,#25,#D7       ;Xe!/f.%W
       DB       #E1,#D8,#AF,#C9,#3E,#10,#32,#BB       ;aX/I>.2;
       DB       #E6,#0E,#1C,#D7,#D8,#3A,#BB,#E6       ;f..WX:;f
       DB       #0E,#0F,#E6,#10,#C4,#10,#00,#D8       ;..f.D..X
       DB       #0E,#20,#D7,#C9,#CD,#9D,#EC,#D8       ;. WIM.lX
       DB       #21,#BB,#E6,#CB,#C6,#21,#AC,#E6       ;!;fKF!,f
       DB       #0E,#33,#D7,#77,#E5,#D9,#EB,#E1       ;.3WweYka
       DB       #23,#73,#23,#72,#C9,#21,#A6,#E6       ;#s#rI!&f
       DB       #18,#EE,#22,#D1,#E6,#7E,#FE,#20       ;.n"Qf~~ 
       DB       #C8,#FE,#0D,#C8,#0E,#AF,#3A,#CC       ;H~.H./:L
       DB       #E6,#91,#C9,#DD,#E5,#AF,#DD,#21       ;f.I]e/]!
       DB       #A6,#E6,#0E,#37,#D7,#DD,#E1,#D8       ;&f.7W]aX
       DB       #F6,#FF,#C9,#3A,#BB,#E6,#CB,#57       ;v.I:;fKW
       DB       #C2,#F6,#EB,#CB,#EF,#32,#BB,#E6       ;BvkKo2;f
       DB       #22,#B7,#E6,#23,#7E,#32,#B9,#E6       ;"7f#~29f
       DB       #CD,#D1,#EC,#C8,#23,#18,#F9,#73       ;MQlH#.ys
       DB       #77,#61,#70,#20,#20,#20,#20,#73       ;wap    s
       DB       #77,#70,#00,#A4,#5D,#80,#07,#00       ;wp.$]...
       DB       #00,#04,#00,#0F,#DD,#22,#17,#ED       ;....]".m
       DB       #22,#56,#ED,#ED,#53,#19,#ED,#0E       ;"VmmS.m.
       DB       #4A,#3E,#51,#D7,#32,#65,#ED,#47       ;J>QW2emG
       DB       #0E,#36,#CD,#91,#ED,#D8,#CD,#98       ;.6M.mXM.
       DB       #EC,#D8,#21,#0B,#ED,#0E,#24,#D7       ;lX!.m.$W
       DB       #D8,#0D,#D7,#D8,#AF,#ED,#62,#0E       ;X.WX/mb.
       DB       #2A,#D7,#D8,#0E,#37,#CD,#91,#ED       ;*WX.7M.m
       DB       #D8,#21,#53,#5E,#0E,#48,#CD,#91       ;X!S^.HM.
       DB       #ED,#D8,#0E,#36,#CD,#91,#ED,#D8       ;mX.6M.mX
       DB       #06,#00,#CD,#98,#EC,#D8,#21,#0B       ;..M.lX!.
       DB       #ED,#0E,#34,#D7,#D8,#D9,#01,#0C       ;m.4WXY..
       DB       #00,#09,#5E,#23,#56,#D5,#DD,#E1       ;..^#VU]a
       DB       #23,#5E,#23,#56,#AF,#ED,#62,#0E       ;#^#V/mb.
       DB       #29,#D7,#D8,#0E,#3C,#D7,#D8,#0E       ;)WX.<WX.
       DB       #02,#D7,#D8,#0E,#37,#AF,#DD,#E5       ;.WX.7/]e
       DB       #DD,#21,#1C,#ED,#D7,#DD,#E1,#C9       ;]!.mW]aI
       DB       #14,#E1,#F1,#1C,#F2,#00,#EE,#C1       ;.aq.r.nA
       DB       #F5,#D2,#F4,#C6,#EE,#63,#EE,#98       ;uRtFncn.
       DB       #EE,#B0,#EE,#B3,#F6,#A0,#F6,#56       ;n0n3v vV
       DB       #F6,#4B,#F6,#7C,#EE,#84,#EE,#13       ;vKv|n.n.
       DB       #F5,#45,#F5,#53,#F5,#79,#F5,#30       ;uEuSuyu0
       DB       #EE,#B9,#EE,#4F,#EE,#DD,#ED,#01       ;n9nOn]m.
       DB       #EE,#4A,#EE,#6C,#F7,#00,#EE,#44       ;nJnlw.nD
       DB       #EE,#DC,#F4,#55,#EE,#5C,#EE,#29       ;n\tUn\n)
       DB       #F1,#A7,#C4,#A5,#FB,#D8,#3A,#06       ;q'D%{X:.
       DB       #F8,#DD,#77,#00,#ED,#5B,#41,#EF       ;x]w.m[Ao
       DB       #DD,#73,#01,#DD,#72,#02,#47,#3A       ;]s.]r.G:
       DB       #0D,#EF,#DD,#77,#03,#DD,#E5,#E1       ;.o]w.]ea
       DB       #DD,#7E,#FD,#D9,#C9,#A7,#C4,#A5       ;]~}YI'D%
       DB       #FB,#D8,#DD,#46,#00,#DD,#E5,#CD       ;{X]F.]eM
       DB       #03,#FA,#DD,#E1,#D8,#DD,#5E,#01       ;.z]aX]^.
       DB       #DD,#56,#02,#DD,#E5,#CD,#1C,#F2       ;]V.]eM.r
       DB       #DD,#E1,#D8,#DD,#7E,#03,#FE,#FF       ;]aX]~.~.
       DB       #28,#D3,#DD,#E5,#CD,#63,#EE,#DD       ;(S]eMcn]
       DB       #E1,#D8,#18,#C9,#ED,#4B,#3A,#EF       ;aX.ImK:o
       DB       #ED,#5B,#43,#EF,#3A,#3E,#EF,#57       ;m[Co:>oW
       DB       #2A,#41,#EF,#3A,#06,#F8,#D9,#C9       ;*Ao:.xYI
       DB       #22,#0A,#EF,#C3,#D0,#F5,#CD,#56       ;".oCPuMV
       DB       #F0,#D9,#C9,#21,#0E,#EF,#D9,#AF       ;pYI!.oY/
       DB       #C9,#CD,#C3,#F2,#D8,#C3,#63,#FD       ;IMCrXCc}
       DB       #CD,#C3,#F2,#D8,#C3,#4B,#FE,#5F       ;MCrXCK~_
       DB       #D5,#CD,#98,#EE,#D1,#D8,#7B,#D9       ;UM.nQX{Y
       DB       #01,#20,#00,#11,#0C,#EF,#12,#13       ;. ...o..
       DB       #12,#13,#D5,#ED,#B0,#E1,#D9,#C9       ;..Um0aYI
       DB       #CD,#8E,#EE,#DD,#E5,#D1,#D9,#C9       ;M.n]eQYI
       DB       #CD,#EA,#EE,#D8,#D5,#DD,#E1,#C3       ;MjnXU]aC
       DB       #71,#FE,#CD,#DB,#EE,#D4,#C3,#F2       ;q~M[nTCr
       DB       #D8,#C3,#79,#FD,#7B,#CD,#68,#F3       ;XCy}{Mhs
       DB       #D8,#16,#00,#D5,#CD,#75,#F3,#C1       ;X..UMusA
       DB       #D8,#79,#E6,#07,#0F,#0F,#0F,#4F       ;Xyf....O
       DB       #09,#D9,#AF,#C9,#3A,#0D,#EF,#32       ;.Y/I:.o2
       DB       #0C,#EF,#C3,#F5,#F3,#CD,#6D,#F4       ;.oCusMmt
       DB       #D8,#21,#0C,#EF,#7E,#23,#77,#23       ;X!.o~#w#
       DB       #D9,#C9,#CD,#B9,#EE,#D8,#3A,#19       ;YIM9nX:.
       DB       #EF,#CB,#6F,#C8,#ED,#5B,#21,#EF       ;oKoHm[!o
       DB       #CD,#1C,#F2,#D8,#3E,#21,#C9,#08       ;M.rX>!I.
       DB       #3A,#19,#EF,#CB,#57,#28,#04,#3E       ;:.oKW(.>
       DB       #AB,#37,#C9,#08,#A7,#C9,#08,#3A       ;+7I.'I.:
       DB       #19,#EF,#CB,#5F,#28,#F5,#3E,#AC       ;.oK_(u>,
       DB       #37,#C9,#80,#0C,#00,#00,#00,#00       ;7I......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#80,#0C,#90,#01,#C3,#5D       ;......C]
       DB       #02,#02,#73,#6C,#61,#62,#61,#67       ;..slabag
       DB       #65,#20,#64,#61,#74,#41,#B4,#5F       ;e datA4_
       DB       #84,#60,#00,#E0,#0A,#00,#00,#00       ;.`.`....
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #86,#1C,#53,#4C,#41,#42,#41,#47       ;..SLABAG
       DB       #45,#20,#20,#20,#20,#21,#AB,#00       ;E    !+.
       DB       #00,#02,#02,#45,#09,#44,#0B,#03       ;...E.D..
       DB       #02,#00,#ED,#73,#F2,#EF,#21,#60       ;..msro!`
       DB       #F1,#E5,#D5,#F5,#CD,#E6,#EF,#22       ;qeUuMfo"
       DB       #B7,#EF,#F1,#D1,#CD,#3C,#F0,#D0       ;7oqQM<pP
       DB       #47,#2C,#79,#95,#12,#EB,#4B,#CD       ;G,y..kKM
       DB       #32,#F0,#08,#91,#38,#14,#CD,#8C       ;2p..8.M.
       DB       #EF,#23,#5E,#23,#56,#23,#4E,#91       ;o#^#V#N.
       DB       #38,#05,#36,#00,#10,#F0,#AF,#2B       ;8.6..p/+
       DB       #2B,#B7,#D5,#F5,#81,#4F,#83,#5F       ;+7Uu.O._
       DB       #30,#01,#14,#F1,#CD,#B1,#EF,#D1       ;0..qM1oQ
       DB       #0C,#0D,#C8,#F5,#C5,#E5,#79,#F5       ;..HuEeyu
       DB       #D5,#CD,#2C,#F0,#D1,#F1,#C4,#33       ;UM,pQqD3
       DB       #F1,#38,#51,#CD,#E6,#EF,#ED,#5B       ;q8QMfom[
       DB       #B7,#EF,#22,#B7,#EF,#ED,#52,#D1       ;7o"7omRQ
       DB       #19,#C1,#F1,#B7,#C9,#C5,#30,#25       ;.Aq7IE0%
       DB       #F5,#D5,#11,#00,#00,#1A,#FE,#54       ;uU....~T
       DB       #3E,#5E,#30,#30,#1A,#3C,#12,#05       ;>^00.<..
       DB       #28,#10,#78,#87,#80,#06,#00,#4F       ;(.x....O
       DB       #54,#5D,#23,#23,#23,#09,#EB,#09       ;T]###.k.
       DB       #ED,#B8,#D1,#23,#F1,#ED,#44,#73       ;m8Q#qmDs
       DB       #23,#72,#23,#77,#C1,#C9,#CD,#29       ;#r#wAIM)
       DB       #F1,#D8,#C5,#ED,#5B,#1F,#EF,#CD       ;qXEm[.oM
       DB       #79,#FD,#C1,#D0,#37,#31,#23,#F9       ;y}AP71#y
       DB       #C9,#ED,#73,#F2,#EF,#21,#60,#F1       ;Imsro!`q
       DB       #E5,#F5,#D5,#D5,#AF,#CD,#4E,#EF       ;euUU/MNo
       DB       #D1,#CD,#3C,#F0,#47,#EB,#D1,#30       ;QM<pGkQ0
       DB       #03,#2B,#2B,#2B,#7E,#CD,#32,#F0       ;.+++~M2p
       DB       #F1,#F5,#C5,#1B,#CD,#59,#F0,#38       ;quE.MYp8
       DB       #D3,#AF,#CD,#8F,#EF,#50,#59,#C1       ;S/M.oPYA
       DB       #F1,#ED,#44,#04,#37,#CD,#B1,#EF       ;qmD.7M1o
       DB       #CD,#C6,#F1,#D0,#18,#BE,#2B,#56       ;MFqP.>+V
       DB       #2B,#86,#5F,#23,#23,#D0,#14,#C9       ;+._##P.I
       DB       #08,#B7,#ED,#62,#44,#37,#ED,#52       ;.7mbD7mR
       DB       #ED,#5B,#B7,#EF,#1A,#B7,#C8,#13       ;m[7o.7H.
       DB       #13,#13,#EB,#4E,#EB,#09,#D8,#3D       ;..kNk.X=
       DB       #18,#F4,#11,#00,#00,#B7,#28,#76       ;.t...7(v
       DB       #F5,#D5,#E5,#67,#08,#7C,#ED,#73       ;uUeg.|ms
       DB       #98,#F0,#2E,#C9,#E5,#21,#CB,#09       ;.p.Ie!K.
       DB       #01,#CE,#00,#0F,#0F,#0F,#18,#02       ;.N......
       DB       #C5,#E5,#D6,#20,#30,#FA,#C6,#20       ;EeV 0zF 
       DB       #47,#C5,#ED,#73,#FA,#F0,#08,#47       ;GEmszp.G
       DB       #CD,#A0,#F0,#11,#00,#00,#DC,#A0       ;M p...\ 
       DB       #F0,#38,#08,#37,#EB,#D5,#78,#CD       ;p8.7kUxM
       DB       #34,#F1,#C1,#31,#29,#F9,#E1,#D1       ;4qA1)yaQ
       DB       #38,#31,#F1,#C9,#CD,#15,#F1,#D8       ;81qIM.qX
       DB       #CD,#F8,#F0,#D4,#D6,#F0,#18,#05       ;MxpTVp..
       DB       #F1,#47,#CD,#F8,#F0,#D8,#7E,#A1       ;qGMxpX~!
       DB       #20,#F8,#C5,#18,#09,#CD,#D6,#F0       ; xE..MVp
       DB       #38,#11,#7E,#A1,#20,#EA,#10,#F5       ;8.~! j.u
       DB       #EB,#29,#29,#29,#2B,#23,#CB,#01       ;k)))+#K.
       DB       #30,#FB,#B7,#C1,#C9,#3C,#C6,#A2       ;0{7AI<F"
       DB       #37,#C9,#CB,#01,#D0,#7B,#1D,#B7       ;7IK.P{.7
       DB       #CC,#E1,#F0,#18,#2A,#15,#37,#F8       ;Lap.*.7x
       DB       #15,#14,#CD,#8D,#FB,#5A,#16,#00       ;..M.{Z..
       DB       #1C,#CD,#79,#FD,#DD,#22,#53,#F1       ;.My}]"Sq
       DB       #22,#0D,#F1,#C9,#AF,#CD,#11,#F9       ;".qI/M.y
       DB       #C8,#83,#5F,#DC,#E5,#F0,#D8,#37       ;H._\epX7
       DB       #2A,#08,#EF,#ED,#52,#3E,#5C,#D8       ;*.omR>\X
       DB       #21,#67,#88,#7A,#16,#00,#19,#57       ;!g.z...W
       DB       #C9,#3E,#07,#A3,#0E,#01,#3C,#CB       ;I>.#..<K
       DB       #09,#3D,#20,#FB,#EB,#CD,#CF,#F1       ;.= {kMOq
       DB       #EB,#15,#37,#18,#D6,#ED,#73,#F2       ;k.7.Vmsr
       DB       #EF,#B7,#28,#A1,#CD,#8D,#FB,#B7       ;o7(!M.{7
       DB       #47,#98,#F5,#CD,#15,#F1,#38,#93       ;G.uM.q8.
       DB       #18,#07,#CB,#09,#DC,#57,#F1,#38       ;..K.\Wq8
       DB       #8A,#F1,#F5,#AE,#A1,#AE,#77,#10       ;.qu.!.w.
       DB       #F1,#F1,#CD,#8D,#FB,#DD,#21,#F7       ;qqM.{]!w
       DB       #80,#18,#72,#1C,#20,#A9,#CD,#4E       ;..r. )MN
       DB       #F1,#D8,#18,#C6,#2A,#B7,#EF,#7E       ;qX.F*7o~
       DB       #F3,#F9,#33,#D9,#3C,#3D,#28,#55       ;sy3Y<=(U
       DB       #D1,#EB,#C1,#3B,#0C,#06,#00,#28       ;QkA;...(
       DB       #F4,#3D,#28,#44,#0D,#28,#22,#D1       ;t=(D.("Q
       DB       #09,#ED,#52,#20,#EC,#39,#08,#7E       ;.mR l9.~
       DB       #81,#38,#07,#70,#3B,#4F,#C5,#08       ;.8.p;OE.
       DB       #18,#29,#3C,#77,#EB,#05,#ED,#42       ;.)<wk.mB
       DB       #E5,#48,#45,#33,#C5,#33,#08,#18       ;eHE3E3..
       DB       #CB,#21,#FD,#FF,#39,#54,#5D,#F9       ;K!}.9T]y
       DB       #23,#23,#23,#4F,#08,#79,#87,#81       ;###O.y..
       DB       #4F,#ED,#B0,#08,#D9,#35,#BE,#D9       ;Om0.Y5>Y
       DB       #30,#B2,#3B,#3B,#3B,#3C,#18,#AC       ;02;;;<.,
       DB       #0D,#20,#02,#D9,#35,#ED,#7B,#F2       ;. .Y5m{r
       DB       #EF,#FB,#CD,#E6,#EF,#C3,#71,#FE       ;o{MfoCq~
       DB       #CD,#D2,#F1,#CD,#D5,#F1,#CD,#D5       ;MRqMUqMU
       DB       #F1,#CB,#3C,#CB,#1D,#C9,#44,#53       ;qK<K.IDS
       DB       #4B,#37,#3E,#57,#C9,#11,#00,#00       ;K7>WI...
       DB       #CD,#79,#FD,#D8,#01,#0A,#00,#09       ;My}X....
       DB       #06,#03,#11,#DA,#F1,#1A,#BE,#20       ;...Zq.> 
       DB       #E8,#13,#23,#10,#F8,#0E,#05,#09       ;h.#.x...
       DB       #7E,#E6,#07,#20,#DC,#5E,#23,#56       ;~f. \^#V
       DB       #EB,#7C,#B5,#28,#D4,#E5,#CD,#80       ;k|5(TeM.
       DB       #F2,#C1,#71,#23,#70,#EB,#23,#5E       ;rAq#pk#^
       DB       #23,#56,#18,#04,#ED,#5B,#41,#EF       ;#V..m[Ao
       DB       #CD,#80,#F2,#4E,#23,#66,#69,#22       ;M.rN#fi"
       DB       #06,#EF,#CD,#CF,#F1,#22,#08,#EF       ;.oMOq".o
       DB       #21,#FF,#FF,#22,#0C,#EF,#D5,#CD       ;!..".oUM
       DB       #79,#FD,#D1,#D8,#E5,#01,#73,#F2       ;y}QXe.sr
       DB       #C5,#01,#08,#00,#09,#06,#03,#3E       ;E......>
       DB       #20,#BE,#C0,#23,#10,#FB,#7E,#2F       ; >@#.{~/
       DB       #E6,#21,#C0,#23,#23,#23,#7E,#E6       ;f!@###~f
       DB       #1F,#C0,#23,#7E,#A7,#C8,#E6,#F0       ;.@#~'Hfp
       DB       #C0,#23,#23,#23,#23,#7E,#23,#66       ;@####~#f
       DB       #6F,#AF,#ED,#52,#C0,#E1,#E1,#11       ;o/mR@aa.
       DB       #2E,#EF,#0E,#17,#ED,#B0,#C9,#F1       ;.o..m0Iq
       DB       #3E,#56,#37,#C9,#7D,#A7,#28,#01       ;>V7I}'(.
       DB       #24,#7C,#A7,#C9,#3A,#06,#F8,#E6       ;$|'I:.xf
       DB       #07,#07,#4F,#06,#00,#21,#F6,#EE       ;..O..!vn
       DB       #09,#C9,#ED,#4B,#08,#EF,#78,#B1       ;.ImK.ox1
       DB       #3E,#6B,#37,#C8,#3A,#45,#EF,#A7       ;>k7H:Eo'
       DB       #C0,#79,#48,#06,#00,#B7,#28,#01       ;@yH..7(.
       DB       #0C,#0C,#E5,#ED,#42,#E1,#3E,#6C       ;..emBa>l
       DB       #C9,#C5,#CD,#05,#F3,#C1,#C9,#C5       ;IEM.sAIE
       DB       #CD,#C3,#F2,#C1,#C9,#3A,#0C,#EF       ;MCrAI:.o
       DB       #A7,#3C,#C0,#3E,#6A,#37,#C9,#CD       ;'<@>j7IM
       DB       #B9,#F2,#D8,#3A,#19,#EF,#CB,#47       ;9rX:.oKG
       DB       #CA,#0E,#F4,#CB,#77,#28,#1E,#E5       ;J.tKw(.e
       DB       #2A,#1D,#EF,#3A,#1C,#EF,#A7,#20       ;*.o:.o' 
       DB       #01,#2B,#ED,#52,#38,#3E,#2A,#1F       ;.+mR8>*.
       DB       #EF,#CD,#8E,#F2,#38,#19,#19,#EB       ;oM.r8..k
       DB       #E1,#AF,#4F,#2F,#C9,#E5,#D5,#ED       ;a/O/IeUm
       DB       #5B,#1F,#EF,#62,#6B,#CD,#8E,#F2       ;[.obkM.r
       DB       #D4,#79,#FD,#D1,#D4,#2B,#F3,#E1       ;Ty}QT+sa
       DB       #C9,#AF,#32,#45,#EF,#CD,#C7,#F4       ;I/2EoMGt
       DB       #28,#15,#7A,#A7,#20,#36,#E5,#2A       ;(.z' 6e*
       DB       #3C,#EF,#CD,#78,#F2,#3D,#BB,#2A       ;<oMxr=;*
       DB       #41,#EF,#30,#C5,#E1,#18,#25,#E5       ;Ao0Ea.%e
       DB       #D5,#ED,#5B,#3F,#EF,#18,#CC,#E5       ;Um[?o.Le
       DB       #EB,#16,#00,#42,#D9,#E1,#CD,#58       ;k..BYaMX
       DB       #F3,#D8,#23,#23,#23,#7E,#A7,#28       ;sX###~'(
       DB       #24,#D9,#5F,#4D,#A7,#ED,#52,#38       ;$Y_M'mR8
       DB       #07,#D9,#10,#EE,#3E,#65,#37,#C9       ;.Y.n>e7I
       DB       #D9,#2B,#56,#2B,#5E,#D5,#D9,#E1       ;Y+V+^UYa
       DB       #09,#EB,#A7,#C9,#7E,#A7,#28,#05       ;.k'I~'(.
       DB       #FE,#56,#3F,#47,#D0,#3E,#55,#37       ;~V?GP>U7
       DB       #C9,#3A,#0C,#EF,#21,#43,#EF,#BE       ;I:.o!Co>
       DB       #3F,#D0,#3E,#50,#C9,#CD,#65,#F3       ;?P>PIMes
       DB       #D8,#E6,#F8,#0F,#0F,#0F,#5F,#16       ;Xfx..._.
       DB       #00,#CD,#05,#F3,#D8,#C3,#79,#FD       ;.M.sXCy}
       DB       #ED,#5B,#0A,#EF,#3A,#0C,#EF,#E6       ;m[.o:.of
       DB       #07,#06,#00,#0F,#0F,#0F,#4F,#09       ;......O.
       DB       #0E,#20,#C9,#21,#19,#EF,#CB,#C6       ;. I!.oKF
       DB       #AF,#32,#1E,#EF,#CD,#CC,#F4,#28       ;/2.oMLt(
       DB       #10,#2A,#1C,#EF,#CD,#78,#F2,#C4       ;.*.oMxrD
       DB       #56,#F0,#D8,#ED,#43,#1F,#EF,#18       ;VpXmC.o.
       DB       #40,#3E,#01,#CD,#56,#F0,#D8,#ED       ;@>.MVpXm
       DB       #43,#1F,#EF,#50,#59,#CD,#79,#FD       ;C.oPYMy}
       DB       #D8,#01,#FF,#00,#CD,#7D,#FC,#CD       ;X...M}|M
       DB       #71,#FE,#D8,#2A,#1C,#EF,#CD,#78       ;q~X*.oMx
       DB       #F2,#28,#1E,#32,#F0,#F3,#CD,#56       ;r(.2psMV
       DB       #F0,#D8,#ED,#5B,#1F,#EF,#C5,#CD       ;pXm[.oEM
       DB       #79,#FD,#C1,#D8,#36,#01,#23,#71       ;y}AX6.#q
       DB       #23,#70,#23,#36,#08,#CD,#71,#FE       ;#p#6.Mq~
       DB       #D8,#CD,#71,#F3,#D8,#CD,#84,#F3       ;XMqsXM.s
       DB       #EB,#21,#0E,#EF,#ED,#B0,#CD,#71       ;k!.om0Mq
       DB       #FE,#D8,#3A,#0C,#EF,#32,#0D,#EF       ;~X:.o2.o
       DB       #AF,#C9,#3E,#58,#37,#C9,#21,#19       ;/I>X7I!.
       DB       #EF,#CB,#46,#28,#F5,#CB,#7E,#3E       ;oKF(uK~>
       DB       #59,#20,#F1,#CB,#86,#CD,#F5,#F3       ;Y qK.Mus
       DB       #D8,#ED,#5B,#1F,#EF,#CD,#CC,#F4       ;Xm[.oMLt
       DB       #28,#0A,#2A,#1C,#EF,#CD,#78,#F2       ;(.*.oMxr
       DB       #C2,#29,#F1,#C9,#21,#1C,#EF,#7E       ;B)qI!.o~
       DB       #23,#B6,#23,#B6,#3E,#01,#CA,#29       ;#6#6>.J)
       DB       #F1,#D5,#CD,#79,#FD,#D1,#D8,#CD       ;qUMy}QXM
       DB       #58,#F3,#D8,#04,#3E,#01,#ED,#62       ;XsX.>.mb
       DB       #A7,#CA,#61,#F3,#E5,#CD,#E2,#EF       ;'JaseMbo
       DB       #D1,#D8,#19,#D5,#23,#5E,#23,#56       ;QX.U#^#V
       DB       #23,#7E,#E1,#23,#23,#23,#10,#E8       ;#~a###.h
       DB       #C9,#22,#0A,#EF,#3E,#0E,#32,#A1       ;I".o>.2!
       DB       #F4,#A7,#28,#02,#3E,#01,#32,#0C       ;t'(.>.2.
       DB       #EF,#CD,#65,#F3,#3C,#D8,#CD,#71       ;oMes<XMq
       DB       #F3,#D8,#E5,#CD,#9D,#F4,#E1,#30       ;sXeM.ta0
       DB       #06,#21,#0C,#EF,#34,#18,#EA,#CD       ;.!.o4.jM
       DB       #84,#F3,#11,#0E,#EF,#ED,#B0,#AF       ;.s..om0/
       DB       #C9,#CD,#84,#F3,#3E,#0E,#CB,#4F       ;IM.s>.KO
       DB       #01,#0B,#00,#20,#06,#09,#EB,#09       ;... ..k.
       DB       #EB,#18,#09,#41,#1A,#BE,#20,#26       ;k..A.> &
       DB       #23,#13,#10,#F8,#3A,#A1,#F4,#A7       ;#..x:!t'
       DB       #CB,#57,#C8,#4E,#CB,#09,#CB,#5F       ;KWHNK.K_
       DB       #C8,#3F,#C9,#3A,#39,#EF,#18,#03       ;H?I:9o..
       DB       #3A,#19,#EF,#E6,#40,#C9,#CD,#6D       ;:.of@IMm
       DB       #F4,#30,#05,#FE,#51,#C8,#37,#C9       ;t0.~QH7I
       DB       #CD,#B9,#F2,#D8,#3A,#19,#EF,#CB       ;M9rX:.oK
       DB       #6F,#3E,#53,#37,#C0,#CD,#12,#F4       ;o>S7@M.t
       DB       #D8,#21,#44,#EF,#35,#ED,#5B,#41       ;X!Do5m[A
       DB       #EF,#CD,#79,#FD,#D8,#EB,#21,#2E       ;oMy}Xk!.
       DB       #EF,#01,#17,#00,#ED,#B0,#C3,#71       ;o...m0Cq
       DB       #FE,#67,#2E,#00,#3A,#19,#EF,#07       ;~g..:.o.
       DB       #07,#7C,#D0,#E1,#3E,#66,#C9,#A7       ;.|Pa>fI'
       DB       #28,#2B,#CD,#05,#F5,#E5,#CD,#F5       ;(+M.ueMu
       DB       #EF,#C1,#D8,#37,#2A,#1C,#EF,#3A       ;oAX7*.o:
       DB       #1E,#EF,#38,#07,#ED,#42,#30,#07       ;.o8.mB0.
       DB       #3D,#18,#04,#09,#30,#01,#3C,#22       ;=...0.<"
       DB       #1C,#EF,#32,#1E,#EF,#C3,#F5,#F3       ;.o2.oCus
       DB       #42,#4B,#7A,#B3,#C0,#3E,#67,#37       ;BKz3@>g7
       DB       #C9,#A7,#28,#F9,#CD,#05,#F5,#E5       ;I'(yM.ue
       DB       #CD,#46,#EF,#C1,#D8,#18,#CD,#CD       ;MFoAX.MM
       DB       #3C,#F5,#D8,#7B,#A7,#28,#0C,#3A       ;<uX{'(.:
       DB       #1C,#EF,#A7,#28,#05,#83,#30,#03       ;.o'(..0.
       DB       #28,#01,#14,#7A,#A7,#28,#B4,#CD       ;(..z'(4M
       DB       #05,#F5,#7A,#11,#FF,#FF,#C5,#18       ;.uz...E.
       DB       #A5,#3E,#68,#37,#C9,#CD,#3C,#F5       ;%>h7IM<u
       DB       #D8,#2A,#1C,#EF,#ED,#52,#30,#06       ;X*.omR0.
       DB       #3A,#1E,#EF,#A7,#28,#EB,#2A,#1C       ;:.o'(k*.
       DB       #EF,#7D,#A7,#28,#06,#93,#38,#02       ;o}'(..8.
       DB       #20,#01,#14,#C5,#7A,#A7,#28,#B3       ; ..Ez'(3
       DB       #4F,#06,#00,#2A,#1D,#EF,#3A,#1C       ;O..*.o:.
       DB       #EF,#A7,#28,#01,#23,#ED,#42,#EB       ;o'(.#mBk
       DB       #CD,#CC,#F4,#7C,#20,#05,#CD,#46       ;MLt| .MF
       DB       #EF,#18,#98,#2A,#1F,#EF,#19,#EB       ;o..*.o.k
       DB       #CD,#29,#F1,#18,#8E,#CD,#6D,#F4       ;M)q..Mmt
       DB       #30,#06,#FE,#51,#28,#06,#37,#C9       ;0.~Q(.7I
       DB       #3E,#52,#37,#C9,#3E,#04,#CD,#72       ;>R7I>.Mr
       DB       #F4,#30,#3D,#FE,#51,#28,#02,#37       ;t0=~Q(.7
       DB       #C9,#21,#44,#EF,#7E,#3C,#07,#3E       ;I!Do~<.>
       DB       #54,#D8,#2A,#3C,#EF,#CD,#CC,#F1       ;TX*<oMLq
       DB       #3A,#43,#EF,#BD,#20,#1A,#AF,#CD       ;:Co= ./M
       DB       #72,#F4,#D8,#11,#20,#00,#CD,#53       ;rtX. .MS
       DB       #F5,#30,#08,#FE,#66,#37,#C0,#3E       ;u0.~f7@>
       DB       #69,#37,#C9,#D8,#CD,#18,#F2,#D8       ;i7IXM.rX
       DB       #21,#43,#EF,#7E,#34,#32,#0C,#EF       ;!Co~42.o
       DB       #2A,#0A,#EF,#11,#0E,#EF,#01,#20       ;*.o..o. 
       DB       #00,#ED,#B0,#CD,#97,#F3,#D8,#21       ;.m0M.sX!
       DB       #44,#EF,#34,#CD,#F1,#F4,#21,#0E       ;Do4Mqt!.
       DB       #EF,#D9,#C9,#3A,#10,#F8,#07,#D2       ;oYI:.x.R
       DB       #5D,#FB,#CD,#4B,#FE,#D8,#24,#13       ;]{MK~X$.
       DB       #10,#F8,#C9,#E5,#21,#2F,#F6,#18       ;.xIe!/v.
       DB       #0A,#E5,#21,#AD,#FC,#18,#0F,#E5       ;.e!-|..e
       DB       #21,#5D,#FB,#CD,#EA,#EE,#30,#0B       ;!]{Mjn0.
       DB       #E1,#C9,#E5,#21,#51,#FB,#CD,#DB       ;aIe!Q{M[
       DB       #EE,#38,#F5,#22,#8F,#F6,#E1,#CD       ;n8u".vaM
       DB       #8D,#FB,#AF,#B0,#C8,#D5,#EB,#48       ;.{/0HUkH
       DB       #06,#00,#09,#EB,#1B,#CD,#B3,#F2       ;...k.M3r
       DB       #D1,#D8,#ED,#53,#98,#F6,#41,#C5       ;QXmS.vAE
       DB       #CD,#C3,#F2,#91,#C1,#47,#79,#90       ;MCr.AGy.
       DB       #38,#03,#4F,#18,#03,#41,#0E,#00       ;8.O..A..
       DB       #E5,#C5,#CD,#AD,#FC,#C1,#E1,#D8       ;eEM-|AaX
       DB       #AF,#B1,#C8,#11,#00,#00,#24,#13       ;/1H...$.
       DB       #10,#FC,#18,#D6,#CD,#EA,#EE,#D8       ;.|.VMjnX
       DB       #F5,#E5,#3E,#EB,#32,#0E,#F7,#32       ;ue>k2.w2
       DB       #3E,#F7,#21,#3F,#F6,#18,#10,#CD       ;>w!?v..M
       DB       #DB,#EE,#D8,#F5,#E5,#AF,#32,#0E       ;[nXue/2.
       DB       #F7,#32,#3E,#F7,#21,#45,#F6,#22       ;w2>w!Ev"
       DB       #2C,#F7,#E1,#F1,#EB,#43,#5A,#57       ;,waqkCZW
       DB       #CD,#49,#F7,#D8,#7D,#B4,#3E,#AA       ;MIwX}4>*
       DB       #37,#C8,#DD,#22,#F4,#F6,#AF,#B0       ;7H]"tv/0
       DB       #28,#44,#22,#FD,#F6,#D5,#C5,#CD       ;(D"}vUEM
       DB       #8E,#EE,#C1,#D1,#D8,#48,#D5,#06       ;.nAQXHU.
       DB       #00,#09,#79,#2F,#3C,#4F,#E5,#21       ;..y/<Oe!
       DB       #C0,#5D,#54,#5D,#09,#22,#F4,#F6       ;@]T]."tv
       DB       #21,#00,#00,#ED,#42,#30,#07,#ED       ;!..mB0.m
       DB       #4B,#FD,#F6,#21,#00,#00,#22,#FD       ;K}v!.."}
       DB       #F6,#E1,#00,#ED,#B0,#D1,#3A,#0E       ;va.m0Q:.
       DB       #F7,#A7,#28,#06,#D5,#CD,#71,#FE       ;w'(.UMq~
       DB       #D1,#D8,#13,#2A,#FD,#F6,#44,#4D       ;QX.*}vDM
       DB       #AF,#B0,#2A,#F4,#F6,#28,#08,#CD       ;/0*tv(.M
       DB       #45,#F6,#D8,#24,#13,#10,#FC,#AF       ;EvX$..|/
       DB       #B1,#C8,#E5,#C5,#CD,#8E,#EE,#C1       ;1HeEM.nA
       DB       #D1,#D8,#00,#ED,#B0,#3A,#3E,#F7       ;QX.m0:>w
       DB       #A7,#C8,#C3,#71,#FE,#CD,#8D,#FB       ;'HCq~M.{
       DB       #AF,#D5,#53,#58,#19,#EB,#2A,#1C       ;/USX.k*.
       DB       #EF,#D9,#D1,#5A,#57,#67,#6F,#ED       ;oYQZWgom
       DB       #5A,#EB,#2A,#1E,#EF,#67,#D9,#ED       ;Zk*.ogYm
       DB       #52,#D9,#ED,#52,#D9,#3E,#64,#C9       ;RYmRY>dI
       DB       #4F,#EB,#B7,#ED,#52,#EB,#19,#EB       ;Ok7mRk.k
       DB       #C5,#E3,#C1,#19,#2B,#56,#2B,#5E       ;EcA.+V+^
       DB       #13,#7A,#B3,#C8,#E5,#D5,#1B,#EB       ;.z3HeU.k
       DB       #09,#EB,#73,#23,#72,#E1,#09,#5E       ;.ks#ra.^
       DB       #23,#56,#2B,#EB,#09,#EB,#73,#23       ;#V+k.ks#
       DB       #72,#E1,#18,#E0,#4B,#FC,#85,#FC       ;ra.`K|.|
       DB       #9C,#FE,#4E,#FE,#63,#FD,#AD,#FC       ;.~N~c}-|
       DB       #91,#F9,#E3,#F7,#E6,#F7,#E9,#F7       ;.ycwfwiw
       DB       #D3,#F9,#F8,#F7,#E5,#F9,#51,#FB       ;SyxweyQ{
       DB       #5D,#FB,#4B,#FB,#89,#F9,#A8,#F9       ;]{K{.y(y
       DB       #B0,#F9,#B9,#F9,#C1,#F9,#5E,#F8       ;0y9yAy^x
       DB       #A5,#FB,#D9,#FB,#A0,#F9,#9B,#F9       ;%{Y{ y.y
       DB       #EF,#F9,#F9,#F9,#03,#FA,#74,#FA       ;oyyy.ztz
       DB       #A3,#FA,#43,#FB,#A1,#6B,#00,#00       ;#zC{!k..
       DB       #08,#FB,#D8,#F7,#00,#00,#10,#C3       ;.{Xw...C
       DB       #ED,#B1,#C3,#AE,#AF,#C3,#CF,#AF       ;m1C./CO/
       DB       #00,#4B,#00,#1D,#01,#13,#B0,#00       ;.K....0.
       DB       #08,#C3,#1F,#BC,#C3,#E0,#BB,#C3       ;.C.<C`;C
       DB       #F3,#BB,#06,#29,#04,#9E,#40,#00       ;s;.)..@.
       DB       #00,#00,#00,#C3,#12,#BE,#C3,#16       ;...C.>C.
       DB       #BE,#C3,#92,#BD,#EC,#80,#E3,#02       ;>C.=l.c.
       DB       #00,#04,#81,#E0,#84,#03,#23,#67       ;...`..#g
       DB       #81,#00,#00,#00       ;....
;L_F820
       DB       #04,#37,#AC,#D3,#67,#DB,#80,#23       ;.7,Sg[.#
       DB       #98,#F7,#9D,#ED,#CA,#E4,#08,#D6       ;.w.mJd.V
       DB       #DB,#C4,#00,#00,#00,#00,#00,#00       ;[D......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #67,#A4,#37,#AC,#A2,#A6,#E8,#CF       ;g$7,"&hO
       DB       #90,#D0,#00,#C3,#5D,#23,#51,#FB       ;.P.C]#Q{
       DB       #C0,#5F,#C0,#60,#E0,#0A,#00,#CD       ;@_@``..M
       DB       #62,#F8,#33,#33,#33,#33,#C9,#1F       ;bx3333I.
       DB       #00,#C9,#D9,#CD,#8D,#FB,#C5,#D9       ;.IYM.{EY
       DB       #C1,#08,#3E,#1F,#A1,#47,#A9,#07       ;A.>.!G).
       DB       #07,#07,#4F,#78,#06,#00,#21,#28       ;..Ox..!(
       DB       #F8,#09,#09,#5E,#23,#56,#EB,#4F       ;x..^#VkO
       DB       #09,#09,#5E,#23,#56,#D5,#08,#D9       ;..^#VU.Y
       DB       #C9,#00,#00,#00,#00,#00,#00,#00       ;I.......
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#00       ;........
       DB       #00,#00,#00,#00,#00,#00,#00,#DB       ;.......[
       DB       #02,#7C,#38,#D1,#BC,#4D,#00,#FA       ;.|8Q<M.z
       DB       #5C,#00,#08,#54,#1F,#45,#39,#A3       ;\..T.E9#
       DB       #39,#DB,#02,#47,#B0,#16,#FB,#FE       ;9[.G0.{~
       DB       #FA,#08,#FB,#E6,#FA,#EF,#80,#68       ;z.{fzo.h
       DB       #92,#34,#00,#03,#02,#45,#39,#45       ;.4...E9E
       DB       #39,#A3,#39,#DB,#02,#7C,#38,#D1       ;9#9[.|8Q
       DB       #BC,#4D,#00,#FA,#5C,#DB,#02,#4D       ;<M.z\[.M
       DB       #00,#FA,#5C,#DB,#02,#4D,#00,#FA       ;.z\[.M.z
       DB       #5C,#3B,#08,#54,#00,#47,#B0,#16       ;\;.T.G0.
       DB       #FB,#FE,#FA,#B1,#B0,#16,#FB,#54       ;{~z10.{T
       DB       #00,#54,#1F,#47,#B0,#16,#FB,#FE       ;.T.G0.{~
       DB       #FA,#08,#FB,#E6,#FA,#27,#81,#38       ;z.{fz'.8
       DB       #00,#00,#00,#15,#3F,#42,#20,#F1       ;....?B q
       DB       #5E,#98,#94,#CF,#00,#6C,#00,#50       ;^..O.l.P
       DB       #FD,#01,#10,#00,#00,#47,#B0,#16       ;}....G0.
       DB       #FB,#FE,#FA,#08,#FB,#E6,#FA,#1B       ;{~z.{fz.
       DB       #81,#68,#92,#00,#00,#2B,#FE,#88       ;.h...+~.
       DB       #FD,#20,#12,#00,#00,#2B,#FE,#A0       ;} ...+~ 
       DB       #F4,#8A,#F4,#96,#F4,#BC,#EE,#9F       ;t.t.t<n.
       DB       #FB,#B5,#5B,#34,#00,#69,#5E,#C3       ;{5[4.i^C
       DB       #5D,#5A,#F8,#FE,#15,#2C,#60,#0E       ;]Zx~.,`.
       DB       #EF,#8E,#5E,#FE,#D2,#9F,#FB,#00       ;o.^~R.{.
       DB       #00,#7E,#00,#A9,#C6,#2F,#D2,#5A       ;.~.)F/RZ
       DB       #F8,#FE,#15,#44,#0B,#CC,#D1,#B8       ;x~.D.LQ8
       DB       #D1,#3A,#1F,#F8,#21,#20,#F8,#D9       ;Q:.x! xY
       DB       #C9,#CD,#79,#FD,#D8,#DD,#E5,#D1       ;IMy}X]eQ
       DB       #79,#D9,#C9,#CD,#F6,#FB,#18,#03       ;yYIMv{..
       DB       #CD,#0F,#FC,#DD,#E5,#E1,#D9,#C9       ;M.|]eaYI
       DB       #11,#E2,#F7,#21,#EC,#F7,#18,#06       ;.bw!lw..
       DB       #11,#F4,#F7,#21,#FE,#F7,#1A,#D9       ;.tw!~w.Y
       DB       #C9,#11,#06,#F8,#21,#10,#F8,#18       ;I..x!.x.
       DB       #F5,#CD,#A5,#FB,#D8,#D9,#7E,#CD       ;uM%{XY~M
       DB       #A5,#FB,#D8,#DD,#6E,#04,#DD,#66       ;%{X]n.]f
       DB       #05,#D9,#C9,#ED,#5B,#01,#F8,#21       ;.YIm[.x!
       DB       #FF,#F7,#34,#D9,#CD,#F5,#F7,#D9       ;.w4YMuwY
       DB       #ED,#53,#01,#F8,#C9,#22,#FF,#F7       ;mS.xI".w
       DB       #4D,#44,#CD,#FB,#F7,#18,#F0,#21       ;MDM{w.p!
       DB       #E3,#F7,#11,#E2,#F7,#0E,#10,#18       ;cw.bw...
       DB       #12,#21,#F5,#F7,#11,#F4,#F7,#0E       ;.!uw.tw.
       DB       #08,#18,#08,#11,#06,#F8,#0E,#00       ;.....x..
       DB       #21,#07,#F8,#78,#E6,#07,#81,#47       ;!.xxf..G
       DB       #1A,#B8,#C8,#4F,#ED,#43,#4E,#F8       ;.8HOmCNx
       DB       #22,#50,#F8,#78,#CD,#A5,#FB,#38       ;"PxxM%{8
       DB       #0A,#DD,#E5,#3A,#4E,#F8,#CD,#A5       ;.]e:NxM%
       DB       #FB,#D9,#D1,#3E,#79,#D8,#D5,#1A       ;{YQ>yXU.
       DB       #BE,#47,#13,#23,#1A,#20,#01,#BE       ;>G.#. .>
       DB       #C4,#25,#FB,#38,#01,#AF,#32,#52       ;D%{8./2R
       DB       #F8,#CD,#90,#FA,#D1,#D5,#1A,#CD       ;xM.zQU.M
       DB       #A5,#FB,#DD,#6E,#04,#DD,#66,#05       ;%{]n.]f.
       DB       #23,#23,#ED,#5B,#50,#F8,#3A,#4F       ;##m[Px:O
       DB       #F8,#1B,#12,#13,#01,#FF,#03,#13       ;x.......
       DB       #ED,#A0,#ED,#A0,#10,#F9,#E1,#23       ;m m .ya#
       DB       #23,#0E,#08,#ED,#B0,#3A,#52,#F8       ;#..m0:Rx
       DB       #A7,#C8,#37,#C9,#32,#4F,#F8,#22       ;'H7I2Ox"
       DB       #50,#F8,#CD,#A5,#FB,#38,#AC,#D9       ;PxM%{8,Y
       DB       #E5,#46,#23,#4E,#CD,#30,#FB,#D1       ;eF#NM0{Q
       DB       #38,#01,#AF,#32,#52,#F8,#18,#B5       ;8./2Rx.5
       DB       #3A,#4E,#F8,#CD,#A5,#FB,#D9,#EB       ;:NxM%{Yk
       DB       #13,#13,#2A,#50,#F8,#01,#09,#00       ;..*Px...
       DB       #09,#18,#C6,#A7,#28,#27,#CD,#B4       ;..F'('M4
       DB       #FA,#C8,#EB,#71,#23,#70,#AF,#0B       ;zHkq#p/.
       DB       #02,#0B,#02,#C9,#4D,#44,#2A,#DC       ;...IMD*\
       DB       #F7,#5D,#54,#7D,#B4,#28,#0B,#ED       ;w]T}4(.m
       DB       #42,#C8,#09,#2B,#56,#2B,#5E,#EB       ;BH.+V+^k
       DB       #18,#F1,#F6,#FF,#C9,#CD,#B4,#FA       ;.qv.IM4z
       DB       #20,#09,#0B,#0B,#0A,#12,#03,#13       ; .......
       DB       #0A,#12,#C9,#3E,#27,#37,#C9,#D5       ;..I>'7IU
       DB       #E5,#DD,#E5,#CD,#F4,#FA,#DD,#E1       ;e]eMtz]a
       DB       #E1,#D1,#C1,#F1,#D9,#08,#E1,#D1       ;aQAqY.aQ
       DB       #C1,#F1,#FB,#C9,#2A,#DC,#F7,#7D       ;Aq{I*\w}
       DB       #B4,#C8,#E5,#CD,#4A,#FB,#E1,#2B       ;4HeMJ{a+
       DB       #56,#2B,#5E,#EB,#18,#F1,#00,#00       ;V+^k.q..
       DB       #3A,#00,#5C,#EE,#C9,#CC,#00,#00       ;:.\nIL..
       DB       #2A,#F1,#F7,#CD,#46,#FB,#2A,#DE       ;*qwMF{*^
       DB       #F7,#06,#04,#34,#C0,#23,#10,#FB       ;w..4@#.{
       DB       #2A,#E0,#F7,#18,#21,#4F,#C5,#0E       ;*`w.!OE.
       DB       #FE,#2B,#46,#CD,#30,#FB,#C1,#D8       ;~+FM0{AX
       DB       #78,#CD,#A5,#FB,#3E,#7A,#D8,#DD       ;xM%{>zX]
       DB       #6E,#04,#DD,#66,#05,#5E,#23,#56       ;n.]f.^#V
       DB       #EB,#18,#03,#2A,#46,#F8,#7D,#B4       ;k..*Fx}4
       DB       #79,#C8,#E9,#CD,#69,#FB,#C3,#0D       ;yHiMi{C.
       DB       #F8,#CD,#69,#FB,#CB,#69,#C2,#07       ;xMi{KiB.
       DB       #F8,#3E,#42,#37,#C9,#CD,#69,#FB       ;x>B7IMi{
       DB       #CB,#71,#C2,#0A,#F8,#3E,#43,#37       ;KqB.x>C7
       DB       #C9,#3A,#10,#F8,#4F,#3A,#06,#F8       ;I:.xO:.x
       DB       #FE,#00,#C8,#32,#71,#FB,#C5,#D5       ;~.H2q{EU
       DB       #CD,#A5,#FB,#38,#0D,#4F,#DD,#CB       ;M%{8.O]K
       DB       #03,#46,#E5,#2A,#48,#F8,#C4,#46       ;.Fe*HxDF
       DB       #FB,#E1,#D1,#C1,#C9,#22,#4B,#F8       ;{aQAI"Kx
       DB       #E3,#DD,#E5,#C5,#D5,#E5,#21,#9F       ;c]eEUe!.
       DB       #FB,#E3,#E5,#2A,#4B,#F8,#C9,#D1       ;{ce*KxIQ
       DB       #C1,#DD,#E1,#E1,#C9,#CD,#B0,#FB       ;A]aaIM0{
       DB       #D8,#ED,#42,#E5,#D9,#DD,#E1,#C9       ;XmBeY]aI
       DB       #B7,#D9,#2A,#40,#F8,#ED,#5B,#44       ;7Y*@xm[D
       DB       #F8,#18,#01,#C8,#ED,#52,#28,#12       ;x..HmR(.
       DB       #30,#0A,#19,#BE,#23,#4E,#23,#46       ;0..>#N#F
       DB       #23,#09,#30,#EF,#08,#3E,#7C,#B7       ;#.0o.>|7
       DB       #18,#04,#08,#AF,#3E,#7D,#D9,#37       ;.../>}Y7
       DB       #C9,#CD,#B0,#FB,#D8,#E5,#ED,#42       ;IM0{XemB
       DB       #2B,#2B,#2B,#EB,#C1,#ED,#42,#28       ;+++kAmB(
       DB       #06,#C5,#44,#4D,#E1,#ED,#B0,#B7       ;.EDMam07
       DB       #ED,#53,#44,#F8,#D9,#C9,#3E,#18       ;mSDxYI>.
       DB       #CD,#0F,#FC,#D0,#20,#08,#08,#3C       ;M.|P ..<
       DB       #FE,#D8,#38,#F4,#3E,#81,#37,#C9       ;~X8t>.7I
       DB       #D1,#08,#AF,#3E,#7E,#37,#C9,#D5       ;Q./>~7IU
       DB       #CD,#B0,#FB,#D9,#30,#F2,#C1,#20       ;M0{Y0rA 
       DB       #BD,#3E,#7F,#B7,#ED,#42,#28,#AF       ;=>.7mB(/
       DB       #2A,#42,#F8,#2B,#2B,#ED,#52,#38       ;*Bx++mR8
       DB       #04,#ED,#42,#30,#04,#3E,#80,#18       ;.mB0.>..
       DB       #9E,#08,#12,#EB,#23,#71,#23,#70       ;...k#q#p
       DB       #23,#E5,#DD,#E1,#54,#5D,#36,#00       ;#e]aT]6.
       DB       #ED,#A0,#E2,#EF,#FB,#2B,#18,#A5       ;m bo{+.%
       DB       #3E,#82,#C9,#26,#00,#4C,#6F,#29       ;>.I&.Lo)
       DB       #29,#E5,#47,#09,#C1,#EB,#2A,#40       ;)eG.Ak*@
       DB       #F8,#ED,#52,#38,#EB,#E5,#ED,#5B       ;xmR8kem[
       DB       #23,#F8,#ED,#52,#E1,#38,#E1,#22       ;#xmRa8a"
       DB       #25,#F8,#32,#27,#F8,#0B,#CD,#7D       ;%x2'x.M}
       DB       #FC,#32,#4D,#F8,#ED,#53,#1B,#F8       ;|2MxmS.x
       DB       #0E,#07,#21,#38,#F8,#AF,#5D,#54       ;..!8x/]T
       DB       #13,#77,#ED,#B0,#C9,#3A,#06,#F8       ;.wm0I:.x
       DB       #CB,#EF,#4F,#CD,#D9,#FF,#7E,#E6       ;KoOMY.~f
       DB       #27,#B9,#20,#0D,#CB,#AE,#DD,#35       ;'9 .K.]5
       DB       #00,#C5,#23,#4E,#2B,#CD,#32,#FE       ;.E#N+M2~
       DB       #C1,#23,#23,#23,#23,#10,#E7,#CD       ;A####.gM
       DB       #E5,#FF,#AF,#77,#C9,#3A,#10,#F8       ;e./wI:.x
       DB       #E6,#80,#CA,#51,#FB,#3A,#27,#F8       ;f.JQ{:'x
       DB       #1F,#B8,#DA,#51,#FB,#ED,#53,#54       ;.8ZQ{mST
       DB       #F8,#22,#52,#F8,#22,#50,#F8,#21       ;x"Rx"Px!
       DB       #5D,#FD,#22,#4E,#F8,#AF,#32,#56       ;]}"Nx/2V
       DB       #F8,#C5,#D5,#CD,#7F,#FD,#0D,#20       ;xEUM.}. 
       DB       #0C,#ED,#5B,#50,#F8,#01,#00,#01       ;.m[Px...
       DB       #ED,#B0,#CD,#EF,#FC,#D1,#C1,#D8       ;m0Mo|QAX
       DB       #13,#21,#51,#F8,#34,#10,#E2,#3A       ;.!Qx4.b:
       DB       #56,#F8,#B7,#20,#07,#21,#53,#F8       ;Vx7 .!Sx
       DB       #34,#23,#34,#C9,#3C,#ED,#5B,#54       ;4#4I<m[T
       DB       #F8,#6F,#47,#AF,#67,#4F,#32,#56       ;xoG/gO2V
       DB       #F8,#19,#22,#54,#F8,#2A,#52,#F8       ;x."Tx*Rx
       DB       #09,#22,#52,#F8,#ED,#42,#05,#C5       ;."RxmB.E
       DB       #D5,#E5,#CD,#51,#FB,#E1,#D1,#C1       ;UeMQ{aQA
       DB       #D8,#48,#0D,#CD,#CA,#FF,#DD,#BE       ;XH.MJ.]>
       DB       #00,#20,#2B,#E5,#DD,#6E,#02,#DD       ;. +e]n.]
       DB       #66,#03,#B7,#ED,#52,#38,#1E,#24       ;f.7mR8.$
       DB       #25,#20,#1A,#08,#79,#BD,#38,#14       ;% ..y=8.
       DB       #7D,#E1,#E5,#84,#67,#D5,#C5,#E5       ;}ae.gUEe
       DB       #CD,#89,#FD,#EB,#E1,#01,#00,#01       ;M.}ka...
       DB       #ED,#B0,#C1,#D1,#08,#E1,#CD,#C2       ;m0AQ.aMB
       DB       #FF,#10,#CB,#AF,#C9,#21,#56,#F8       ;..K/I!Vx
       DB       #34,#AF,#C9,#06,#01,#3A,#10,#F8       ;4/I..:.x
       DB       #07,#D2,#51,#FB,#E5,#CD,#79,#FD       ;.RQ{eMy}
       DB       #D1,#D8,#01,#00,#01,#ED,#B0,#AF       ;QX...m0/
       DB       #C9,#21,#51,#FB,#22,#4E,#F8,#CD       ;I!Q{"NxM
       DB       #03,#FE,#38,#13,#C5,#CD,#25,#FE       ;.~8.EM%~
       DB       #C1,#3A,#27,#F8,#90,#2A,#1B,#F8       ;A:'x.*.x
       DB       #47,#0E,#00,#09,#0C,#AF,#C9,#D5       ;G..../IU
       DB       #CD,#C2,#FD,#D1,#D8,#DD,#71,#01       ;MB}QX]q.
       DB       #79,#32,#4D,#F8,#DD,#73,#02,#DD       ;y2Mx]s.]
       DB       #72,#03,#CD,#89,#FD,#DD,#E5,#E5       ;r.M.}]ee
       DB       #06,#01,#CD,#FD,#FD,#E1,#DD,#E1       ;..M}}a]a
       DB       #F5,#3A,#06,#F8,#CB,#EF,#0E,#00       ;u:.xKo..
       DB       #18,#36,#CD,#D9,#FF,#AF,#4F,#3D       ;.6MY./O=
       DB       #CB,#6E,#28,#23,#CB,#7E,#23,#20       ;Kn(#K~# 
       DB       #08,#BE,#38,#05,#7E,#48,#54,#5D       ;.>8.~HT]
       DB       #1B,#23,#23,#23,#10,#EA,#41,#4F       ;.###.jAO
       DB       #04,#05,#3E,#41,#37,#C8,#C5,#CD       ;..>A7HEM
       DB       #32,#FE,#C1,#EB,#DD,#35,#00,#DD       ;2~Ak]5.]
       DB       #4E,#00,#0C,#E5,#DD,#E1,#AF,#F5       ;N..e]a/u
       DB       #DD,#77,#00,#F1,#C9       ;]w.qI
        endif
	if 1==0
;
        ds L_FDFD-$
	JP	Imer
;
        ds L_FE00-$
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD,#FD,#FD,#FD,#FD,#FD,#FD,#FD
       DB       #FD
	endif
      if 1==0
;
;L_FF01
       DB       #50,#1B,#16,#DC,#0A,#CE,#0B,#E7       ;P..\.N.g
       DB       #50,#C2,#5C,#54,#1F,#2F,#3D,#A0       ;PB\T./= 
       DB       #3D,#C2,#5C,#DB,#02,#4D,#00,#DB       ;=B\[.M.[
       DB       #02,#4D,#00,#0A,#00,#99,#10,#00       ;.M......
       DB       #00,#44,#09,#B4,#30,#00,#00,#42       ;.D.40..B
       DB       #00,#35,#30,#2B,#5E,#B1,#33,#26       ;.50+^13&
       DB       #5E       ;^
       DB       #2C,#5E,#DB,#02,#4D,#00,#0C,#57       ;,^[.M..W
       DB       #F4,#00,#0B,#57,#8C,#08,#5C,#0E       ;t..W..\.
       DB       #00,#47,#C0,#57,#71,#0E,#F3,#0D       ;.G@Wq.s.
       DB       #21,#17,#C6,#1E,#FF,#5F,#76,#1B       ;!.F.._v.
       DB       #1D,#5B,#00,#3E,#14,#1B,#00,#18       ;.[.>....
       DB       #24       ;$
       DB       #42,#7E,#42,#42,#00,#00,#7C,#22       ;B~BB..|"
       DB       #3C,#22,#22,#7C,#00,#00,#3C,#42       ;<""|..<B
       DB       #40,#40,#42,#3C,#00,#00,#7C,#22       ;@@B<..|"
       DB       #22,#22,#22,#7C,#00,#00,#7E,#20       ;"""|..~ 
       DB       #3C,#20,#20,#7E,#00,#00,#7E,#20       ;<  ~..~ 
       DB       #3C,#20,#20,#70,#00,#00,#3C,#42       ;<  p..<B
       DB       #40,#4E,#42,#3C,#00,#00,#42,#42       ;@NB<..BB
       DB       #7E,#42,#42,#42,#00,#00,#3E,#08       ;~BBB..>.
       DB       #08,#08,#08,#3E,#00,#00,#1E,#04       ;...>....
       DB       #04,#44,#44,#38,#00,#00,#44,#48       ;.DD8..DH
       DB       #70,#48,#44,#42,#00,#00,#70,#20       ;pHDB..p 
       DB       #20,#20,#22,#7E,#00,#00,#42,#66       ;  "~..Bf
       DB       #5A,#C2,#5C,#54,#1F,#2F,#3D,#A0       ;ZB\T./= 
       DB       #3D,#C2,#5C,#DB,#02,#4D,#00,#70       ;=B\[.M.p
       DB       #56,#90,#00,#6F,#56,#8C,#08,#5C       ;V..oV..\
       DB       #0E,#00,#47,#C0,#57,#71,#0E,#F3       ;..G@Wq.s
       DB       #0D,#C2,#5C,#6C,#5D,#2F,#3D,#B7       ;.B\l]/=7
       DB       #2D,#6C,#5D,#67,#5D,#48,#5D,#2B       ;-l]g]H]+
       DB       #2D,#65,#33,#58,#27,#ED,#10,#31       ;-e3X'm.1
       DB       #00,#7B,#00,#85,#1C,#52,#1B,#76       ;.{...R.v
       DB       #1B,#1D,#5B,#3C,#3E       ;..[<>
      endif
;L_FFFF       EQU       $-1
;#0000
;
