CHIME
        CALL    PUSHA
        LD      DE,#0E00
        LD      HL,CHIMEBF
        LD      BC,#FFFD
CHIME1
        LD      A,(HL)
        OUT     (C),E
        LD      B,#BF
        OUT     (C),A
        LD      B,#FF
        INC     HL
        INC     E
        DEC     D
        JP      Z,POPA
        JR      CHIME1

CHIMEBF
        DEFW    #01A6,#014F,#011A
        DEFB    0,#78,#10,#10,#10,0,8,0,0
OHL
        DEFW    0

PUSHA
        LD      (OHL),HL
        POP     HL      ;Return address
        LD      (PA1+1),HL
        LD      HL,(OHL)
        PUSH    AF
        PUSH    BC
        PUSH    DE
        PUSH    HL
        PUSH    IX
        PUSH    IY
PA1
        JP      0

POPA
        POP     IY
        POP     IX
        POP     HL
        POP     DE
        POP     BC
        POP     AF
        RET 
